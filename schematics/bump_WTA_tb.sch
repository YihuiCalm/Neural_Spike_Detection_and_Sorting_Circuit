v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 802.5 -3250 832.5 -3250 { lab=LPbias2}
N 802.5 -3210 832.5 -3210 { lab=LPbias1}
N 672.5 -3250 672.5 -3230 { lab=#net1}
N 672.5 -3230 832.5 -3230 { lab=#net1}
N 802.5 -3140 832.5 -3140 { lab=LPbias2}
N 802.5 -3100 832.5 -3100 { lab=LPbias1}
N 672.5 -3140 672.5 -3120 { lab=#net2}
N 672.5 -3120 832.5 -3120 { lab=#net2}
N 802.5 -3040 832.5 -3040 { lab=LPbias2}
N 802.5 -3000 832.5 -3000 { lab=LPbias1}
N 672.5 -3040 672.5 -3020 { lab=#net3}
N 672.5 -3020 832.5 -3020 { lab=#net3}
N 802.5 -2940 832.5 -2940 { lab=LPbias2}
N 802.5 -2900 832.5 -2900 { lab=LPbias1}
N 672.5 -2940 672.5 -2920 { lab=#net4}
N 672.5 -2920 832.5 -2920 { lab=#net4}
N 3720 -1687.5 3720 -1627.5 { lab=#net5}
N 3720 -1687.5 3810 -1687.5 { lab=#net5}
N 3760 -1597.5 3850 -1597.5 { lab=#net6}
N 6847.5 -2242.5 6847.5 -2182.5 { lab=#net7}
N 6847.5 -2242.5 6937.5 -2242.5 { lab=#net7}
N 6887.5 -2152.5 6977.5 -2152.5 { lab=#net8}
N 6977.5 -2212.5 6977.5 -2102.5 { lab=#net8}
N 6647.5 -1982.5 6977.5 -1982.5 { lab=#net9}
N 6817.5 -1982.5 6817.5 -1962.5 { lab=#net9}
N 3850 -1657.5 3850 -1547.5 { lab=#net6}
N 6977.5 -2042.5 6977.5 -1982.5 { lab=#net9}
N 6817.5 -1902.5 6817.5 -1882.5 { lab=#net10}
N 3415 -1887.5 3415 -1837.5 { lab=#net11}
N 3215 -1917.5 3375 -1917.5 { lab=vand_1}
N 3455 -2087.5 3615 -2087.5 { lab=VDD}
N 3255 -1887.5 3575 -1887.5 { lab=#net11}
N 3575 -2057.5 3575 -1887.5 { lab=#net11}
N 3455 -2207.5 3625 -2207.5 { lab=#net12}
N 3415 -2177.5 3545 -2177.5 { lab=#net12}
N 3545 -2207.5 3545 -2177.5 { lab=#net12}
N 3415 -2177.5 3415 -2117.5 { lab=#net12}
N 3415 -2057.5 3415 -1947.5 { lab=#net13}
N 3185 -1917.5 3215 -1917.5 { lab=vand_1}
N 3625 -2207.5 3655 -2207.5 { lab=#net12}
N 3695 -2117.5 3695 -1747.5 { lab=#net5}
N 3695 -1747.5 3720 -1747.5 { lab=#net5}
N 3720 -1747.5 3720 -1687.5 { lab=#net5}
N 2585 -2015 2585 -1955 { lab=vnxor_1_1}
N 2585 -1955 2785 -1955 { lab=vnxor_1_1}
N 2585 -1927.5 2585 -1915 { lab=vnxor_2_1}
N 2585 -1915 2785 -1915 { lab=vnxor_2_1}
N 2585 -1867.5 2782.5 -1867.5 { lab=vnxor_3_1}
N 2585 -1867.5 2585 -1845 { lab=vnxor_3_1}
N 2585 -1827.5 2782.5 -1827.5 { lab=vnxor_4_1}
N 2585 -1827.5 2585 -1767.5 { lab=vnxor_4_1}
N 2785 -1955 2830 -1917.5 { lab=vnxor_1_1}
N 2785 -1915 2830 -1897.5 { lab=vnxor_2_1}
N 2782.5 -1867.5 2830 -1877.5 { lab=vnxor_3_1}
N 2782.5 -1827.5 2830 -1857.5 { lab=vnxor_4_1}
N 3130 -1917.5 3185 -1917.5 { lab=vand_1}
N 3725 -892.5 3725 -832.5 { lab=#net14}
N 3725 -892.5 3815 -892.5 { lab=#net14}
N 3765 -802.5 3855 -802.5 { lab=#net15}
N 3855 -862.5 3855 -752.5 { lab=#net15}
N 3855 -692.5 3855 -632.5 { lab=#net9}
N 3420 -1092.5 3420 -1042.5 { lab=#net16}
N 3220 -1122.5 3380 -1122.5 { lab=vand_2}
N 3460 -1292.5 3620 -1292.5 { lab=VDD}
N 3260 -1092.5 3580 -1092.5 { lab=#net16}
N 3580 -1262.5 3580 -1092.5 { lab=#net16}
N 3460 -1412.5 3630 -1412.5 { lab=#net17}
N 3420 -1382.5 3550 -1382.5 { lab=#net17}
N 3550 -1412.5 3550 -1382.5 { lab=#net17}
N 3420 -1382.5 3420 -1322.5 { lab=#net17}
N 3420 -1262.5 3420 -1152.5 { lab=#net18}
N 3190 -1122.5 3220 -1122.5 { lab=vand_2}
N 3630 -1412.5 3660 -1412.5 { lab=#net17}
N 3700 -1322.5 3700 -952.5 { lab=#net14}
N 3700 -952.5 3725 -952.5 { lab=#net14}
N 3725 -952.5 3725 -892.5 { lab=#net14}
N 2590 -1220 2590 -1160 { lab=vnxor_1_2}
N 2590 -1160 2790 -1160 { lab=vnxor_1_2}
N 2590 -1132.5 2590 -1120 { lab=vnxor_2_2}
N 2590 -1120 2790 -1120 { lab=vnxor_2_2}
N 2590 -1072.5 2787.5 -1072.5 { lab=vnxor_3_2}
N 2590 -1072.5 2590 -1050 { lab=vnxor_3_2}
N 2590 -1032.5 2787.5 -1032.5 { lab=vnxor_4_2}
N 2590 -1032.5 2590 -972.5 { lab=vnxor_4_2}
N 2790 -1160 2835 -1122.5 { lab=vnxor_1_2}
N 2790 -1120 2835 -1102.5 { lab=vnxor_2_2}
N 2787.5 -1072.5 2835 -1082.5 { lab=vnxor_3_2}
N 2787.5 -1032.5 2835 -1062.5 { lab=vnxor_4_2}
N 3135 -1122.5 3190 -1122.5 { lab=vand_2}
N 4075 -1152.5 4075 452.5 { lab=#net9}
N 3855 -632.5 4075 -632.5 { lab=#net9}
N 3850 -1487.5 4075 -1487.5 { lab=#net9}
N 3725 62.5 3725 122.5 { lab=#net19}
N 3725 62.5 3815 62.5 { lab=#net19}
N 3765 152.5 3855 152.5 { lab=#net20}
N 3855 92.5 3855 202.5 { lab=#net20}
N 3855 262.5 3855 322.5 { lab=#net9}
N 3420 -137.5 3420 -87.5 { lab=#net21}
N 3220 -167.5 3380 -167.5 { lab=vand_3}
N 3460 -337.5 3620 -337.5 { lab=VDD}
N 3260 -137.5 3580 -137.5 { lab=#net21}
N 3580 -307.5 3580 -137.5 { lab=#net21}
N 3460 -457.5 3630 -457.5 { lab=#net22}
N 3420 -427.5 3550 -427.5 { lab=#net22}
N 3550 -457.5 3550 -427.5 { lab=#net22}
N 3420 -427.5 3420 -367.5 { lab=#net22}
N 3420 -307.5 3420 -197.5 { lab=#net23}
N 3190 -167.5 3220 -167.5 { lab=vand_3}
N 3630 -457.5 3660 -457.5 { lab=#net22}
N 3700 -367.5 3700 2.5 { lab=#net19}
N 3700 2.5 3725 2.5 { lab=#net19}
N 3725 2.5 3725 62.5 { lab=#net19}
N 2590 -265 2590 -205 { lab=vnxor_1_3}
N 2590 -205 2790 -205 { lab=vnxor_1_3}
N 2590 -177.5 2590 -165 { lab=vnxor_2_3}
N 2590 -165 2790 -165 { lab=vnxor_2_3}
N 2590 -117.5 2787.5 -117.5 { lab=vnxor_3_3}
N 2590 -117.5 2590 -95 { lab=vnxor_3_3}
N 2590 -77.5 2787.5 -77.5 { lab=vnxor_4_3}
N 2590 -77.5 2590 -17.5 { lab=vnxor_4_3}
N 2790 -205 2835 -167.5 { lab=vnxor_1_3}
N 2790 -165 2835 -147.5 { lab=vnxor_2_3}
N 2787.5 -117.5 2835 -127.5 { lab=vnxor_3_3}
N 2787.5 -77.5 2835 -107.5 { lab=vnxor_4_3}
N 3135 -167.5 3190 -167.5 { lab=vand_3}
N 3855 322.5 4075 322.5 { lab=#net9}
N 5932.5 -1687.5 5932.5 -1627.5 { lab=#net24}
N 5932.5 -1687.5 6022.5 -1687.5 { lab=#net24}
N 5972.5 -1597.5 6062.5 -1597.5 { lab=#net25}
N 6062.5 -1657.5 6062.5 -1547.5 { lab=#net25}
N 6062.5 -1487.5 6062.5 -1427.5 { lab=#net9}
N 5627.5 -1887.5 5627.5 -1837.5 { lab=#net26}
N 5427.5 -1917.5 5587.5 -1917.5 { lab=vand_4}
N 5667.5 -2087.5 5827.5 -2087.5 { lab=VDD}
N 5467.5 -1887.5 5787.5 -1887.5 { lab=#net26}
N 5787.5 -2057.5 5787.5 -1887.5 { lab=#net26}
N 5667.5 -2207.5 5837.5 -2207.5 { lab=#net27}
N 5627.5 -2177.5 5757.5 -2177.5 { lab=#net27}
N 5757.5 -2207.5 5757.5 -2177.5 { lab=#net27}
N 5627.5 -2177.5 5627.5 -2117.5 { lab=#net27}
N 5627.5 -2057.5 5627.5 -1947.5 { lab=#net28}
N 5397.5 -1917.5 5427.5 -1917.5 { lab=vand_4}
N 5837.5 -2207.5 5867.5 -2207.5 { lab=#net27}
N 5907.5 -2117.5 5907.5 -1747.5 { lab=#net24}
N 5907.5 -1747.5 5932.5 -1747.5 { lab=#net24}
N 5932.5 -1747.5 5932.5 -1687.5 { lab=#net24}
N 4797.5 -2015 4797.5 -1955 { lab=vnxor_1_4}
N 4797.5 -1955 4997.5 -1955 { lab=vnxor_1_4}
N 4797.5 -1927.5 4797.5 -1915 { lab=vnxor_2_4}
N 4797.5 -1915 4997.5 -1915 { lab=vnxor_2_4}
N 4797.5 -1867.5 4995 -1867.5 { lab=vnxor_3_4}
N 4797.5 -1867.5 4797.5 -1845 { lab=vnxor_3_4}
N 4797.5 -1827.5 4995 -1827.5 { lab=vnxor_4_4}
N 4797.5 -1827.5 4797.5 -1767.5 { lab=vnxor_4_4}
N 4997.5 -1955 5042.5 -1917.5 { lab=vnxor_1_4}
N 4997.5 -1915 5042.5 -1897.5 { lab=vnxor_2_4}
N 4995 -1867.5 5042.5 -1877.5 { lab=vnxor_3_4}
N 4995 -1827.5 5042.5 -1857.5 { lab=vnxor_4_4}
N 5342.5 -1917.5 5397.5 -1917.5 { lab=vand_4}
N 6062.5 -1427.5 6282.5 -1427.5 { lab=#net9}
N 6282.5 -2310 6282.5 -1427.5 { lab=#net9}
N 5932.5 -685 5932.5 -625 { lab=#net29}
N 5932.5 -685 6022.5 -685 { lab=#net29}
N 5972.5 -595 6062.5 -595 { lab=#net30}
N 6062.5 -655 6062.5 -545 { lab=#net30}
N 6062.5 -485 6062.5 -425 { lab=#net9}
N 5627.5 -885 5627.5 -835 { lab=#net31}
N 5427.5 -915 5587.5 -915 { lab=vand_5}
N 5667.5 -1085 5827.5 -1085 { lab=VDD}
N 5467.5 -885 5787.5 -885 { lab=#net31}
N 5787.5 -1055 5787.5 -885 { lab=#net31}
N 5667.5 -1205 5837.5 -1205 { lab=#net32}
N 5627.5 -1175 5757.5 -1175 { lab=#net32}
N 5757.5 -1205 5757.5 -1175 { lab=#net32}
N 5627.5 -1175 5627.5 -1115 { lab=#net32}
N 5627.5 -1055 5627.5 -945 { lab=#net33}
N 5397.5 -915 5427.5 -915 { lab=vand_5}
N 5837.5 -1205 5867.5 -1205 { lab=#net32}
N 5907.5 -1115 5907.5 -745 { lab=#net29}
N 5907.5 -745 5932.5 -745 { lab=#net29}
N 5932.5 -745 5932.5 -685 { lab=#net29}
N 4797.5 -1012.5 4797.5 -952.5 { lab=vnxor_1_5}
N 4797.5 -952.5 4997.5 -952.5 { lab=vnxor_1_5}
N 4797.5 -925 4797.5 -912.5 { lab=vnxor_2_5}
N 4797.5 -912.5 4997.5 -912.5 { lab=vnxor_2_5}
N 4797.5 -865 4995 -865 { lab=vnxor_3_5}
N 4797.5 -865 4797.5 -842.5 { lab=vnxor_3_5}
N 4797.5 -825 4995 -825 { lab=vnxor_4_5}
N 4797.5 -825 4797.5 -765 { lab=vnxor_4_5}
N 4997.5 -952.5 5042.5 -915 { lab=vnxor_1_5}
N 4997.5 -912.5 5042.5 -895 { lab=vnxor_2_5}
N 4995 -865 5042.5 -875 { lab=vnxor_3_5}
N 4995 -825 5042.5 -855 { lab=vnxor_4_5}
N 5342.5 -915 5397.5 -915 { lab=vand_5}
N 6062.5 -425 6282.5 -425 { lab=#net9}
N 5932.5 327.5 5932.5 387.5 { lab=#net34}
N 5932.5 327.5 6022.5 327.5 { lab=#net34}
N 5972.5 417.5 6062.5 417.5 { lab=#net35}
N 6062.5 357.5 6062.5 467.5 { lab=#net35}
N 6062.5 527.5 6062.5 587.5 { lab=#net9}
N 5627.5 127.5 5627.5 177.5 { lab=#net36}
N 5427.5 97.5 5587.5 97.5 { lab=vand_6}
N 5667.5 -72.5 5827.5 -72.5 { lab=VDD}
N 5467.5 127.5 5787.5 127.5 { lab=#net36}
N 5787.5 -42.5 5787.5 127.5 { lab=#net36}
N 5667.5 -192.5 5837.5 -192.5 { lab=#net37}
N 5627.5 -162.5 5757.5 -162.5 { lab=#net37}
N 5757.5 -192.5 5757.5 -162.5 { lab=#net37}
N 5627.5 -162.5 5627.5 -102.5 { lab=#net37}
N 5627.5 -42.5 5627.5 67.5 { lab=#net38}
N 5397.5 97.5 5427.5 97.5 { lab=vand_6}
N 5837.5 -192.5 5867.5 -192.5 { lab=#net37}
N 5907.5 -102.5 5907.5 267.5 { lab=#net34}
N 5907.5 267.5 5932.5 267.5 { lab=#net34}
N 5932.5 267.5 5932.5 327.5 { lab=#net34}
N 4797.5 0 4797.5 60 { lab=vnxor_1_6}
N 4797.5 60 4997.5 60 { lab=vnxor_1_6}
N 4797.5 87.5 4797.5 100 { lab=vnxor_2_6}
N 4797.5 100 4997.5 100 { lab=vnxor_2_6}
N 4797.5 147.5 4995 147.5 { lab=vnxor_3_6}
N 4797.5 147.5 4797.5 170 { lab=vnxor_3_6}
N 4797.5 187.5 4995 187.5 { lab=vnxor_4_6}
N 4797.5 187.5 4797.5 247.5 { lab=vnxor_4_6}
N 4997.5 60 5042.5 97.5 { lab=vnxor_1_6}
N 4997.5 100 5042.5 117.5 { lab=vnxor_2_6}
N 4995 147.5 5042.5 137.5 { lab=vnxor_3_6}
N 4995 187.5 5042.5 157.5 { lab=vnxor_4_6}
N 5342.5 97.5 5397.5 97.5 { lab=vand_6}
N 6062.5 587.5 6282.5 587.5 { lab=#net9}
N 6282.5 -295 6282.5 587.5 { lab=#net9}
N 6282.5 -1427.5 6282.5 -295 { lab=#net9}
N 4075 -1487.5 4075 -1152.5 { lab=#net9}
N 4075 587.5 6062.5 587.5 { lab=#net9}
N 4075 452.5 4075 587.5 { lab=#net9}
N 6282.5 -2310 6647.5 -2310 { lab=#net9}
N 6647.5 -2310 6647.5 -1982.5 { lab=#net9}
C {devices/gnd.sym} 575 -312.5 0 0 {name=l1 lab=GND}
C {devices/vdd.sym} 495 -372.5 0 0 {name=l8 lab=VDD}
C {devices/vsource.sym} 495 -282.5 0 0 {name=V2 value=5.0}
C {devices/gnd.sym} 495 -252.5 0 0 {name=l9 lab=GND}
C {devices/code.sym} 1147.5 -610 0 0 {name=TT_MODELS only_toplevel=true
format="tcleval( @value )"
value=".lib \\\\$::SKYWATER_MODELS\\\\/models/sky130.lib.spice tt

.param mc_mm_switch=0
.param mc_pr_switch=1
"}
C {devices/vsource.sym} 575 -342.5 0 0 {name=V5 value=0.4}
C {devices/lab_pin.sym} 575 -372.5 3 1 {name=l17 sig_type=std_logic lab=HPbias

}
C {devices/gnd.sym} 645 -312.5 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} 645 -372.5 3 1 {name=l19 sig_type=std_logic lab=VREF

}
C {devices/vsource.sym} 645 -342.5 0 0 {name=V6 value=2.0}
C {devices/vsource.sym} 715 -342.5 0 0 {name=V3 value=0.543v}
C {devices/gnd.sym} 715 -312.5 0 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} 715 -372.5 3 1 {name=l15 sig_type=std_logic lab=LPbias1

}
C {devices/vsource.sym} 785 -342.5 0 0 {name=V4 value=0.4v}
C {devices/gnd.sym} 785 -312.5 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 785 -372.5 3 1 {name=l21 sig_type=std_logic lab=LPbias2

}
C {devices/lab_pin.sym} 385 -215 1 0 {name=l61 sig_type=std_logic lab=vbias_bump}
C {devices/gnd.sym} 385 -155 0 0 {name=l62 lab=GND}
C {devices/vsource.sym} 385 -185 0 0 {name=Vbias5 value=3v}
C {devices/lab_pin.sym} 305 -215 1 0 {name=l63 sig_type=std_logic lab=vbias_WTA}
C {devices/gnd.sym} 305 -155 0 0 {name=l64 lab=GND}
C {devices/vsource.sym} 305 -185 0 0 {name=Vbias6 value=3v}
C {devices/code_shown.sym} 210 -935 0 0 {name=SPICE only_toplevel=false value="
.model fsrc1 filesource(file=\\"data/eval_dataset/electrode_ch1.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a1 %v[vin_1] fsrc1
.model fsrc2 filesource(file=\\"data/eval_dataset/electrode_ch2.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a2 %v[vin_2] fsrc2
.model fsrc3 filesource(file=\\"data/eval_dataset/electrode_ch3.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a3 %v[vin_3] fsrc3
.model fsrc4 filesource(file=\\"data/eval_dataset/electrode_ch4.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a4 %v[vin_4] fsrc4
.model fsrc5 filesource(file=\\"data/eval_dataset/teach_ch1.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a5 %v[vg_1] fsrc5
.model fsrc6 filesource(file=\\"data/eval_dataset/teach_ch2.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a6 %v[vg_2] fsrc6
.model fsrc7 filesource(file=\\"data/eval_dataset/teach_ch3.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a7 %v[vg_3] fsrc7
.model fsrc8 filesource(file=\\"data/eval_dataset/teach_ch4.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a8 %v[vg_4] fsrc8
.model fsrc9 filesource(file=\\"data/eval_dataset/teach_ch5.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a9 %v[vg_5] fsrc9
.model fsrc10 filesource(file=\\"data/eval_dataset/teach_ch6.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a10 %v[vg_6] fsrc10
.control
save all
tran 1000us 600ms uic
plot i(Vmeas_in_1) i(Vmeas_in_2) i(Vmeas_in_3) i(Vmeas_in_4) i(Vmeas_in_5) i(Vmeas_in_6)
plot v(vand_1) v(vand_2) v(vand_3) v(vand_4) v(vand_5) v(vand_6)
plot v(vout_1) v(vout_2) v(vout_3) v(vout_4) v(vout_5) v(vout_6)
.endc
"}
C {devices/lab_pin.sym} 382.5 -3250 0 0 {name=l58 sig_type=std_logic lab=vin_1
}
C {/media/sf_share/Highpass_500Hz.sym} 532.5 -3230 0 0 {name=x6}
C {devices/lab_pin.sym} 382.5 -3230 2 1 {name=l78 sig_type=std_logic lab=HPbias

}
C {devices/lab_pin.sym} 382.5 -3210 2 1 {name=l79 sig_type=std_logic lab=VREF

}
C {/media/sf_share/Lowpass_2500Hz.sym} 982.5 -3230 0 0 {name=x7}
C {devices/lab_pin.sym} 802.5 -3210 2 1 {name=l80 sig_type=std_logic lab=LPbias1

}
C {devices/lab_pin.sym} 802.5 -3250 2 1 {name=l81 sig_type=std_logic lab=LPbias2

}
C {/media/sf_share/final_project/schmitt_trigger.sym} 1282.5 -3250 0 0 {name=x8}
C {devices/lab_pin.sym} 1132.5 -3250 3 0 {name=l82 sig_type=std_logic lab=vfilter_1

}
C {devices/lab_pin.sym} 1282.5 -3250 2 0 {name=l83 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 382.5 -3140 0 0 {name=l84 sig_type=std_logic lab=vin_2
}
C {/media/sf_share/Highpass_500Hz.sym} 532.5 -3120 0 0 {name=x9}
C {devices/lab_pin.sym} 382.5 -3120 2 1 {name=l85 sig_type=std_logic lab=HPbias

}
C {devices/lab_pin.sym} 382.5 -3100 2 1 {name=l86 sig_type=std_logic lab=VREF

}
C {/media/sf_share/Lowpass_2500Hz.sym} 982.5 -3120 0 0 {name=x10}
C {devices/lab_pin.sym} 802.5 -3100 2 1 {name=l87 sig_type=std_logic lab=LPbias1

}
C {devices/lab_pin.sym} 802.5 -3140 2 1 {name=l88 sig_type=std_logic lab=LPbias2

}
C {/media/sf_share/final_project/schmitt_trigger.sym} 1282.5 -3140 0 0 {name=x11}
C {devices/lab_pin.sym} 1282.5 -3140 2 0 {name=l89 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 382.5 -3040 0 0 {name=l90 sig_type=std_logic lab=vin_3
}
C {/media/sf_share/Highpass_500Hz.sym} 532.5 -3020 0 0 {name=x12}
C {devices/lab_pin.sym} 382.5 -3020 2 1 {name=l91 sig_type=std_logic lab=HPbias

}
C {devices/lab_pin.sym} 382.5 -3000 2 1 {name=l92 sig_type=std_logic lab=VREF

}
C {/media/sf_share/Lowpass_2500Hz.sym} 982.5 -3020 0 0 {name=x13}
C {devices/lab_pin.sym} 802.5 -3000 2 1 {name=l93 sig_type=std_logic lab=LPbias1

}
C {devices/lab_pin.sym} 802.5 -3040 2 1 {name=l94 sig_type=std_logic lab=LPbias2

}
C {/media/sf_share/final_project/schmitt_trigger.sym} 1282.5 -3040 0 0 {name=x14}
C {devices/lab_pin.sym} 1282.5 -3040 2 0 {name=l95 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 382.5 -2940 0 0 {name=l96 sig_type=std_logic lab=vin_4
}
C {/media/sf_share/Highpass_500Hz.sym} 532.5 -2920 0 0 {name=x15}
C {devices/lab_pin.sym} 382.5 -2920 2 1 {name=l97 sig_type=std_logic lab=HPbias

}
C {devices/lab_pin.sym} 382.5 -2900 2 1 {name=l98 sig_type=std_logic lab=VREF

}
C {/media/sf_share/Lowpass_2500Hz.sym} 982.5 -2920 0 0 {name=x16}
C {devices/lab_pin.sym} 802.5 -2900 2 1 {name=l99 sig_type=std_logic lab=LPbias1

}
C {devices/lab_pin.sym} 802.5 -2940 2 1 {name=l100 sig_type=std_logic lab=LPbias2

}
C {/media/sf_share/final_project/schmitt_trigger.sym} 1282.5 -2940 0 0 {name=x17}
C {devices/lab_pin.sym} 1282.5 -2940 2 0 {name=l101 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 1132.5 -3140 3 0 {name=l102 sig_type=std_logic lab=vfilter_2

}
C {devices/lab_pin.sym} 1132.5 -3040 3 0 {name=l103 sig_type=std_logic lab=vfilter_3

}
C {devices/lab_pin.sym} 1132.5 -2940 3 0 {name=l104 sig_type=std_logic lab=vfilter_4

}
C {/media/sf_share/final_project/cap_mem.sym} 1745 -3370 0 0 {name=x18}
C {devices/lab_pin.sym} 1595 -3350 0 0 {name=l3 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1825 -3410 0 1 {name=l5 sig_type=std_logic lab=vmem_1_1
}
C {devices/lab_pin.sym} 1670 -3300 3 0 {name=l7 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1692.5 -3300 3 0 {name=l10 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1595 -3390 2 1 {name=l11 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 1595 -3410 2 1 {name=l13 sig_type=std_logic lab=vg_1

}
C {/media/sf_share/final_project/cap_mem.sym} 1745 -3180 0 0 {name=x1}
C {devices/lab_pin.sym} 1595 -3160 0 0 {name=l106 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1825 -3220 0 1 {name=l107 sig_type=std_logic lab=vmem_2_1
}
C {devices/lab_pin.sym} 1670 -3110 3 0 {name=l108 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1692.5 -3110 3 0 {name=l109 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1595 -3200 2 1 {name=l110 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 1595 -3220 2 1 {name=l111 sig_type=std_logic lab=vg_1

}
C {/media/sf_share/final_project/cap_mem.sym} 1745 -2990 0 0 {name=x2}
C {devices/lab_pin.sym} 1595 -2970 0 0 {name=l113 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1825 -3030 0 1 {name=l114 sig_type=std_logic lab=vmem_3_1
}
C {devices/lab_pin.sym} 1670 -2920 3 0 {name=l115 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1692.5 -2920 3 0 {name=l116 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1595 -3010 2 1 {name=l117 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 1595 -3030 2 1 {name=l118 sig_type=std_logic lab=vg_1

}
C {/media/sf_share/final_project/cap_mem.sym} 1745 -2800 0 0 {name=x3}
C {devices/lab_pin.sym} 1595 -2780 0 0 {name=l120 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1825 -2840 0 1 {name=l121 sig_type=std_logic lab=vmem_4_1
}
C {devices/lab_pin.sym} 1670 -2730 3 0 {name=l122 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1692.5 -2730 3 0 {name=l123 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1595 -2820 2 1 {name=l124 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 1595 -2840 2 1 {name=l125 sig_type=std_logic lab=vg_1

}
C {devices/ammeter.sym} 3695 -2147.5 0 0 {name=Vmeas_bump_1}
C {devices/vdd.sym} 3695 -2237.5 0 0 {name=l4 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3740 -1597.5 0 1 {name=M8
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3830 -1687.5 0 0 {name=M9
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 3720 -1567.5 0 0 {name=l6 lab=GND}
C {devices/vdd.sym} 3850 -1717.5 0 0 {name=l12 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 6867.5 -2152.5 0 1 {name=M10
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 6957.5 -2242.5 0 0 {name=M11
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 6847.5 -2122.5 0 0 {name=l20 lab=GND}
C {devices/vdd.sym} 6977.5 -2272.5 0 0 {name=l22 lab=VDD}
C {devices/isource.sym} 6847.5 -2272.5 0 0 {name=I0 value=8uA}
C {devices/vdd.sym} 6847.5 -2302.5 0 0 {name=l25 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 6797.5 -1852.5 0 0 {name=M12
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 6817.5 -1822.5 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} 6777.5 -1852.5 0 0 {name=l27 sig_type=std_logic lab=vbias_WTA}
C {devices/ammeter.sym} 3850 -1517.5 0 0 {name=Vmeas_in_1}
C {devices/ammeter.sym} 6977.5 -2072.5 0 0 {name=Vmeas_ref}
C {devices/ammeter.sym} 6817.5 -1932.5 0 0 {name=Vmeas_bais}
C {/media/sf_share/final_project/nxor.sym} 2542.5 -2005 0 0 {name=x5}
C {devices/lab_pin.sym} 2392.5 -2015 0 0 {name=l28 sig_type=std_logic lab=vmem_1_1
}
C {devices/lab_pin.sym} 2392.5 -1995 2 1 {name=l43 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 3197.5 -1917.5 1 0 {name=l53 sig_type=std_logic lab=vand_1
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3435 -2087.5 0 1 {name=M6
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3235 -1917.5 0 0 {name=M7
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3395 -1917.5 0 0 {name=M2
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3595 -2087.5 0 1 {name=M3
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3435 -1807.5 0 1 {name=M4
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 3415 -2237.5 0 0 {name=l29 lab=VDD}
C {devices/gnd.sym} 3415 -1777.5 0 0 {name=l30 lab=GND}
C {devices/lab_pin.sym} 3455 -1807.5 0 1 {name=l31 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 3255 -1947.5 0 0 {name=l32 lab=VDD}
C {devices/vdd.sym} 3575 -2117.5 0 0 {name=l33 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3435 -2207.5 0 1 {name=M5
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3675 -2207.5 0 0 {name=M1
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2585 -2015 2 0 {name=l56 sig_type=std_logic lab=vnxor_1_1
}
C {devices/lab_pin.sym} 1172.5 -387.5 1 0 {name=l144 sig_type=std_logic lab=vbias}
C {devices/gnd.sym} 1172.5 -327.5 0 0 {name=l145 lab=GND}
C {devices/vsource.sym} 1172.5 -357.5 0 0 {name=Vbias3 value=2v}
C {devices/lab_pin.sym} 1407.5 -387.5 1 0 {name=l148 sig_type=std_logic lab=vbias1}
C {devices/gnd.sym} 1407.5 -327.5 0 0 {name=l149 lab=GND}
C {devices/vsource.sym} 1407.5 -357.5 0 0 {name=Vbias9 value=2v}
C {devices/lab_pin.sym} 1530 -390 1 0 {name=l150 sig_type=std_logic lab=vbias2}
C {devices/gnd.sym} 1530 -330 0 0 {name=l151 lab=GND}
C {devices/vsource.sym} 1530 -360 0 0 {name=Vbias10 value=1.1v}
C {/media/sf_share/final_project/nxor.sym} 2542.5 -1917.5 0 0 {name=x19}
C {devices/lab_pin.sym} 2392.5 -1927.5 0 0 {name=l23 sig_type=std_logic lab=vmem_2_1
}
C {devices/lab_pin.sym} 2392.5 -1907.5 2 1 {name=l24 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 2585 -1927.5 2 0 {name=l35 sig_type=std_logic lab=vnxor_2_1
}
C {/media/sf_share/final_project/nxor.sym} 2542.5 -1835 0 0 {name=x20}
C {devices/lab_pin.sym} 2392.5 -1845 0 0 {name=l39 sig_type=std_logic lab=vmem_3_1
}
C {devices/lab_pin.sym} 2392.5 -1825 2 1 {name=l40 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 2585 -1845 2 0 {name=l41 sig_type=std_logic lab=vnxor_3_1
}
C {/media/sf_share/final_project/nxor.sym} 2542.5 -1757.5 0 0 {name=x21}
C {devices/lab_pin.sym} 2392.5 -1767.5 0 0 {name=l42 sig_type=std_logic lab=vmem_4_1
}
C {devices/lab_pin.sym} 2392.5 -1747.5 2 1 {name=l44 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 2585 -1767.5 2 0 {name=l45 sig_type=std_logic lab=vnxor_4_1}
C {devices/lab_pin.sym} 3855 -1850 0 1 {name=l46 sig_type=std_logic lab=vout_1}
C {/media/sf_share/final_project/and5.sym} 2980 -1877.5 0 0 {name=x22}
C {devices/vdd.sym} 3615 -2087.5 0 0 {name=l34 lab=VDD}
C {devices/ammeter.sym} 3700 -1352.5 0 0 {name=Vmeas_bump_2}
C {devices/vdd.sym} 3700 -1442.5 0 0 {name=l36 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3745 -802.5 0 1 {name=M13
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3835 -892.5 0 0 {name=M14
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 3725 -772.5 0 0 {name=l37 lab=GND}
C {devices/vdd.sym} 3855 -922.5 0 0 {name=l38 lab=VDD}
C {devices/ammeter.sym} 3855 -722.5 0 0 {name=Vmeas_in_2}
C {/media/sf_share/final_project/nxor.sym} 2547.5 -1210 0 0 {name=x4}
C {devices/lab_pin.sym} 2397.5 -1220 0 0 {name=l51 sig_type=std_logic lab=vmem_1_2
}
C {devices/lab_pin.sym} 2397.5 -1200 2 1 {name=l52 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 3202.5 -1122.5 1 0 {name=l54 sig_type=std_logic lab=vand_2
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3440 -1292.5 0 1 {name=M15
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3240 -1122.5 0 0 {name=M16
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3400 -1122.5 0 0 {name=M17
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3600 -1292.5 0 1 {name=M18
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3440 -1012.5 0 1 {name=M19
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 3420 -1442.5 0 0 {name=l55 lab=VDD}
C {devices/gnd.sym} 3420 -982.5 0 0 {name=l57 lab=GND}
C {devices/lab_pin.sym} 3460 -1012.5 0 1 {name=l59 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 3260 -1152.5 0 0 {name=l60 lab=VDD}
C {devices/vdd.sym} 3580 -1322.5 0 0 {name=l65 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3440 -1412.5 0 1 {name=M20
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3680 -1412.5 0 0 {name=M21
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2590 -1220 2 0 {name=l66 sig_type=std_logic lab=vnxor_1_2
}
C {/media/sf_share/final_project/nxor.sym} 2547.5 -1122.5 0 0 {name=x24}
C {devices/lab_pin.sym} 2397.5 -1132.5 0 0 {name=l67 sig_type=std_logic lab=vmem_2_2
}
C {devices/lab_pin.sym} 2397.5 -1112.5 2 1 {name=l68 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 2590 -1132.5 2 0 {name=l69 sig_type=std_logic lab=vnxor_2_2
}
C {/media/sf_share/final_project/nxor.sym} 2547.5 -1040 0 0 {name=x25}
C {devices/lab_pin.sym} 2397.5 -1050 0 0 {name=l70 sig_type=std_logic lab=vmem_3_2
}
C {devices/lab_pin.sym} 2397.5 -1030 2 1 {name=l71 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 2590 -1050 2 0 {name=l72 sig_type=std_logic lab=vnxor_3_2
}
C {/media/sf_share/final_project/nxor.sym} 2547.5 -962.5 0 0 {name=x26}
C {devices/lab_pin.sym} 2397.5 -972.5 0 0 {name=l73 sig_type=std_logic lab=vmem_4_2
}
C {devices/lab_pin.sym} 2397.5 -952.5 2 1 {name=l74 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 2590 -972.5 2 0 {name=l75 sig_type=std_logic lab=vnxor_4_2
}
C {/media/sf_share/final_project/and5.sym} 2985 -1082.5 0 0 {name=x27}
C {devices/vdd.sym} 3620 -1292.5 0 0 {name=l129 lab=VDD}
C {devices/vdd.sym} 2830 -1837.5 3 0 {name=l47 lab=VDD}
C {devices/vdd.sym} 2835 -1042.5 3 0 {name=l48 lab=VDD}
C {/media/sf_share/final_project/cap_mem.sym} 2217.5 -3372.5 0 0 {name=x23}
C {devices/lab_pin.sym} 2067.5 -3352.5 0 0 {name=l50 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2297.5 -3412.5 0 1 {name=l77 sig_type=std_logic lab=vmem_1_2
}
C {devices/lab_pin.sym} 2142.5 -3302.5 3 0 {name=l126 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2165 -3302.5 3 0 {name=l127 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2067.5 -3392.5 2 1 {name=l128 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 2067.5 -3412.5 2 1 {name=l130 sig_type=std_logic lab=vg_2

}
C {/media/sf_share/final_project/cap_mem.sym} 2217.5 -3182.5 0 0 {name=x28}
C {devices/lab_pin.sym} 2067.5 -3162.5 0 0 {name=l132 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2297.5 -3222.5 0 1 {name=l133 sig_type=std_logic lab=vmem_2_2
}
C {devices/lab_pin.sym} 2142.5 -3112.5 3 0 {name=l134 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2165 -3112.5 3 0 {name=l135 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2067.5 -3202.5 2 1 {name=l136 sig_type=std_logic lab=vspike_2

}
C {/media/sf_share/final_project/cap_mem.sym} 2217.5 -2992.5 0 0 {name=x29}
C {devices/lab_pin.sym} 2067.5 -2972.5 0 0 {name=l139 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2297.5 -3032.5 0 1 {name=l140 sig_type=std_logic lab=vmem_3_2
}
C {devices/lab_pin.sym} 2142.5 -2922.5 3 0 {name=l141 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2165 -2922.5 3 0 {name=l152 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2067.5 -3012.5 2 1 {name=l153 sig_type=std_logic lab=vspike_3

}
C {/media/sf_share/final_project/cap_mem.sym} 2217.5 -2802.5 0 0 {name=x30}
C {devices/lab_pin.sym} 2067.5 -2782.5 0 0 {name=l156 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2297.5 -2842.5 0 1 {name=l157 sig_type=std_logic lab=vmem_4_2
}
C {devices/lab_pin.sym} 2142.5 -2732.5 3 0 {name=l158 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2165 -2732.5 3 0 {name=l159 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2067.5 -2822.5 2 1 {name=l160 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 2067.5 -3222.5 2 1 {name=l137 sig_type=std_logic lab=vg_2

}
C {devices/lab_pin.sym} 2067.5 -3032.5 2 1 {name=l154 sig_type=std_logic lab=vg_2

}
C {devices/lab_pin.sym} 2067.5 -2842.5 2 1 {name=l161 sig_type=std_logic lab=vg_2

}
C {devices/ammeter.sym} 3700 -397.5 0 0 {name=Vmeas_bump_3}
C {devices/vdd.sym} 3700 -487.5 0 0 {name=l142 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3745 152.5 0 1 {name=M22
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3835 62.5 0 0 {name=M23
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 3725 182.5 0 0 {name=l143 lab=GND}
C {devices/vdd.sym} 3855 32.5 0 0 {name=l162 lab=VDD}
C {devices/ammeter.sym} 3855 232.5 0 0 {name=Vmeas_in_3}
C {/media/sf_share/final_project/nxor.sym} 2547.5 -255 0 0 {name=x31}
C {devices/lab_pin.sym} 2397.5 -265 0 0 {name=l163 sig_type=std_logic lab=vmem_1_3
}
C {devices/lab_pin.sym} 2397.5 -245 2 1 {name=l164 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 3202.5 -167.5 1 0 {name=l165 sig_type=std_logic lab=vand_3
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3440 -337.5 0 1 {name=M24
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3240 -167.5 0 0 {name=M25
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3400 -167.5 0 0 {name=M26
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3600 -337.5 0 1 {name=M27
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3440 -57.5 0 1 {name=M28
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 3420 -487.5 0 0 {name=l166 lab=VDD}
C {devices/gnd.sym} 3420 -27.5 0 0 {name=l167 lab=GND}
C {devices/lab_pin.sym} 3460 -57.5 0 1 {name=l168 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 3260 -197.5 0 0 {name=l169 lab=VDD}
C {devices/vdd.sym} 3580 -367.5 0 0 {name=l170 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3440 -457.5 0 1 {name=M29
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3680 -457.5 0 0 {name=M30
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2590 -265 2 0 {name=l171 sig_type=std_logic lab=vnxor_1_3
}
C {/media/sf_share/final_project/nxor.sym} 2547.5 -167.5 0 0 {name=x32}
C {devices/lab_pin.sym} 2397.5 -177.5 0 0 {name=l172 sig_type=std_logic lab=vmem_2_3
}
C {devices/lab_pin.sym} 2397.5 -157.5 2 1 {name=l173 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 2590 -177.5 2 0 {name=l174 sig_type=std_logic lab=vnxor_2_3
}
C {/media/sf_share/final_project/nxor.sym} 2547.5 -85 0 0 {name=x33}
C {devices/lab_pin.sym} 2397.5 -95 0 0 {name=l175 sig_type=std_logic lab=vmem_3_3
}
C {devices/lab_pin.sym} 2397.5 -75 2 1 {name=l176 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 2590 -95 2 0 {name=l177 sig_type=std_logic lab=vnxor_3_3
}
C {/media/sf_share/final_project/nxor.sym} 2547.5 -7.5 0 0 {name=x34}
C {devices/lab_pin.sym} 2397.5 -17.5 0 0 {name=l178 sig_type=std_logic lab=vmem_4_3
}
C {devices/lab_pin.sym} 2397.5 2.5 2 1 {name=l179 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 2590 -17.5 2 0 {name=l180 sig_type=std_logic lab=vnxor_4_3
}
C {/media/sf_share/final_project/and5.sym} 2985 -127.5 0 0 {name=x35}
C {devices/vdd.sym} 3620 -337.5 0 0 {name=l182 lab=VDD}
C {devices/vdd.sym} 2835 -87.5 3 0 {name=l183 lab=VDD}
C {devices/ammeter.sym} 5907.5 -2147.5 0 0 {name=Vmeas_bump_4}
C {devices/vdd.sym} 5907.5 -2237.5 0 0 {name=l184 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5952.5 -1597.5 0 1 {name=M31
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 6042.5 -1687.5 0 0 {name=M32
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 5932.5 -1567.5 0 0 {name=l185 lab=GND}
C {devices/vdd.sym} 6062.5 -1717.5 0 0 {name=l186 lab=VDD}
C {devices/ammeter.sym} 6062.5 -1517.5 0 0 {name=Vmeas_in_4}
C {/media/sf_share/final_project/nxor.sym} 4755 -2005 0 0 {name=x36}
C {devices/lab_pin.sym} 4605 -2015 0 0 {name=l187 sig_type=std_logic lab=vmem_1_4
}
C {devices/lab_pin.sym} 4605 -1995 2 1 {name=l188 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 5410 -1917.5 1 0 {name=l189 sig_type=std_logic lab=vand_4
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5647.5 -2087.5 0 1 {name=M33
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5447.5 -1917.5 0 0 {name=M34
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5607.5 -1917.5 0 0 {name=M35
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5807.5 -2087.5 0 1 {name=M36
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5647.5 -1807.5 0 1 {name=M37
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5627.5 -2237.5 0 0 {name=l190 lab=VDD}
C {devices/gnd.sym} 5627.5 -1777.5 0 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} 5667.5 -1807.5 0 1 {name=l192 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 5467.5 -1947.5 0 0 {name=l193 lab=VDD}
C {devices/vdd.sym} 5787.5 -2117.5 0 0 {name=l194 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5647.5 -2207.5 0 1 {name=M38
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5887.5 -2207.5 0 0 {name=M39
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4797.5 -2015 2 0 {name=l195 sig_type=std_logic lab=vnxor_1_4
}
C {/media/sf_share/final_project/nxor.sym} 4755 -1917.5 0 0 {name=x37}
C {devices/lab_pin.sym} 4605 -1927.5 0 0 {name=l196 sig_type=std_logic lab=vmem_2_4
}
C {devices/lab_pin.sym} 4605 -1907.5 2 1 {name=l197 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 4797.5 -1927.5 2 0 {name=l198 sig_type=std_logic lab=vnxor_2_4
}
C {/media/sf_share/final_project/nxor.sym} 4755 -1835 0 0 {name=x38}
C {devices/lab_pin.sym} 4605 -1845 0 0 {name=l199 sig_type=std_logic lab=vmem_3_4
}
C {devices/lab_pin.sym} 4605 -1825 2 1 {name=l200 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 4797.5 -1845 2 0 {name=l201 sig_type=std_logic lab=vnxor_3_4
}
C {/media/sf_share/final_project/nxor.sym} 4755 -1757.5 0 0 {name=x39}
C {devices/lab_pin.sym} 4605 -1767.5 0 0 {name=l202 sig_type=std_logic lab=vmem_4_4
}
C {devices/lab_pin.sym} 4605 -1747.5 2 1 {name=l203 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 4797.5 -1767.5 2 0 {name=l204 sig_type=std_logic lab=vnxor_4_4
}
C {/media/sf_share/final_project/and5.sym} 5192.5 -1877.5 0 0 {name=x40}
C {devices/vdd.sym} 5827.5 -2087.5 0 0 {name=l206 lab=VDD}
C {devices/vdd.sym} 5042.5 -1837.5 3 0 {name=l207 lab=VDD}
C {/media/sf_share/final_project/cap_mem.sym} 2687.5 -3372.5 0 0 {name=x41}
C {devices/lab_pin.sym} 2537.5 -3352.5 0 0 {name=l209 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2767.5 -3412.5 0 1 {name=l210 sig_type=std_logic lab=vmem_1_3
}
C {devices/lab_pin.sym} 2612.5 -3302.5 3 0 {name=l211 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2635 -3302.5 3 0 {name=l212 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2537.5 -3392.5 2 1 {name=l213 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 2537.5 -3412.5 2 1 {name=l214 sig_type=std_logic lab=vg_3

}
C {/media/sf_share/final_project/cap_mem.sym} 2687.5 -3182.5 0 0 {name=x42}
C {devices/lab_pin.sym} 2537.5 -3162.5 0 0 {name=l216 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2767.5 -3222.5 0 1 {name=l217 sig_type=std_logic lab=vmem_2_3
}
C {devices/lab_pin.sym} 2612.5 -3112.5 3 0 {name=l218 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2635 -3112.5 3 0 {name=l219 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2537.5 -3202.5 2 1 {name=l220 sig_type=std_logic lab=vspike_2

}
C {/media/sf_share/final_project/cap_mem.sym} 2687.5 -2992.5 0 0 {name=x43}
C {devices/lab_pin.sym} 2537.5 -2972.5 0 0 {name=l222 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2767.5 -3032.5 0 1 {name=l223 sig_type=std_logic lab=vmem_3_3
}
C {devices/lab_pin.sym} 2612.5 -2922.5 3 0 {name=l224 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2635 -2922.5 3 0 {name=l225 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2537.5 -3012.5 2 1 {name=l226 sig_type=std_logic lab=vspike_3

}
C {/media/sf_share/final_project/cap_mem.sym} 2687.5 -2802.5 0 0 {name=x44}
C {devices/lab_pin.sym} 2537.5 -2782.5 0 0 {name=l228 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2767.5 -2842.5 0 1 {name=l229 sig_type=std_logic lab=vmem_4_3
}
C {devices/lab_pin.sym} 2612.5 -2732.5 3 0 {name=l230 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2635 -2732.5 3 0 {name=l231 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2537.5 -2822.5 2 1 {name=l232 sig_type=std_logic lab=vspike_4

}
C {/media/sf_share/final_project/cap_mem.sym} 3167.5 -3372.5 0 0 {name=x45}
C {devices/lab_pin.sym} 3017.5 -3352.5 0 0 {name=l237 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3247.5 -3412.5 0 1 {name=l238 sig_type=std_logic lab=vmem_1_4
}
C {devices/lab_pin.sym} 3092.5 -3302.5 3 0 {name=l239 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3115 -3302.5 3 0 {name=l240 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3017.5 -3392.5 2 1 {name=l241 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 3017.5 -3412.5 2 1 {name=l242 sig_type=std_logic lab=vg_4

}
C {/media/sf_share/final_project/cap_mem.sym} 3167.5 -3182.5 0 0 {name=x46}
C {devices/lab_pin.sym} 3017.5 -3162.5 0 0 {name=l244 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3247.5 -3222.5 0 1 {name=l245 sig_type=std_logic lab=vmem_2_4
}
C {devices/lab_pin.sym} 3092.5 -3112.5 3 0 {name=l246 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3115 -3112.5 3 0 {name=l247 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3017.5 -3202.5 2 1 {name=l248 sig_type=std_logic lab=vspike_2

}
C {/media/sf_share/final_project/cap_mem.sym} 3167.5 -2992.5 0 0 {name=x47}
C {devices/lab_pin.sym} 3017.5 -2972.5 0 0 {name=l250 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3247.5 -3032.5 0 1 {name=l251 sig_type=std_logic lab=vmem_3_4
}
C {devices/lab_pin.sym} 3092.5 -2922.5 3 0 {name=l252 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3115 -2922.5 3 0 {name=l253 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3017.5 -3012.5 2 1 {name=l254 sig_type=std_logic lab=vspike_3

}
C {/media/sf_share/final_project/cap_mem.sym} 3167.5 -2802.5 0 0 {name=x48}
C {devices/lab_pin.sym} 3017.5 -2782.5 0 0 {name=l256 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3247.5 -2842.5 0 1 {name=l257 sig_type=std_logic lab=vmem_4_4
}
C {devices/lab_pin.sym} 3092.5 -2732.5 3 0 {name=l258 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3115 -2732.5 3 0 {name=l259 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3017.5 -2822.5 2 1 {name=l260 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 2537.5 -3222.5 2 1 {name=l233 sig_type=std_logic lab=vg_3

}
C {devices/lab_pin.sym} 2537.5 -3032.5 2 1 {name=l234 sig_type=std_logic lab=vg_3

}
C {devices/lab_pin.sym} 2537.5 -2842.5 2 1 {name=l235 sig_type=std_logic lab=vg_3

}
C {devices/lab_pin.sym} 3017.5 -3222.5 2 1 {name=l261 sig_type=std_logic lab=vg_4

}
C {devices/lab_pin.sym} 3017.5 -3032.5 2 1 {name=l262 sig_type=std_logic lab=vg_4

}
C {devices/lab_pin.sym} 3017.5 -2842.5 2 1 {name=l263 sig_type=std_logic lab=vg_4

}
C {devices/ammeter.sym} 5907.5 -1145 0 0 {name=Vmeas_bump_5}
C {devices/vdd.sym} 5907.5 -1235 0 0 {name=l2 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5952.5 -595 0 1 {name=M40
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 6042.5 -685 0 0 {name=M41
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 5932.5 -565 0 0 {name=l49 lab=GND}
C {devices/vdd.sym} 6062.5 -715 0 0 {name=l105 lab=VDD}
C {devices/ammeter.sym} 6062.5 -515 0 0 {name=Vmeas_in_6}
C {/media/sf_share/final_project/nxor.sym} 4755 -1002.5 0 0 {name=x49}
C {devices/lab_pin.sym} 4605 -1012.5 0 0 {name=l112 sig_type=std_logic lab=vmem_1_5
}
C {devices/lab_pin.sym} 4605 -992.5 2 1 {name=l119 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 5410 -915 1 0 {name=l131 sig_type=std_logic lab=vand_5
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5647.5 -1085 0 1 {name=M42
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5447.5 -915 0 0 {name=M43
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5607.5 -915 0 0 {name=M44
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5807.5 -1085 0 1 {name=M45
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5647.5 -805 0 1 {name=M46
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5627.5 -1235 0 0 {name=l138 lab=VDD}
C {devices/gnd.sym} 5627.5 -775 0 0 {name=l146 lab=GND}
C {devices/lab_pin.sym} 5667.5 -805 0 1 {name=l147 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 5467.5 -945 0 0 {name=l155 lab=VDD}
C {devices/vdd.sym} 5787.5 -1115 0 0 {name=l208 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5647.5 -1205 0 1 {name=M47
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5887.5 -1205 0 0 {name=M48
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4797.5 -1012.5 2 0 {name=l215 sig_type=std_logic lab=vnxor_1_5
}
C {/media/sf_share/final_project/nxor.sym} 4755 -915 0 0 {name=x50}
C {devices/lab_pin.sym} 4605 -925 0 0 {name=l221 sig_type=std_logic lab=vmem_2_5
}
C {devices/lab_pin.sym} 4605 -905 2 1 {name=l227 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 4797.5 -925 2 0 {name=l236 sig_type=std_logic lab=vnxor_2_5
}
C {/media/sf_share/final_project/nxor.sym} 4755 -832.5 0 0 {name=x51}
C {devices/lab_pin.sym} 4605 -842.5 0 0 {name=l243 sig_type=std_logic lab=vmem_3_5
}
C {devices/lab_pin.sym} 4605 -822.5 2 1 {name=l249 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 4797.5 -842.5 2 0 {name=l255 sig_type=std_logic lab=vnxor_3_5
}
C {/media/sf_share/final_project/nxor.sym} 4755 -755 0 0 {name=x52}
C {devices/lab_pin.sym} 4605 -765 0 0 {name=l264 sig_type=std_logic lab=vmem_4_5
}
C {devices/lab_pin.sym} 4605 -745 2 1 {name=l265 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 4797.5 -765 2 0 {name=l266 sig_type=std_logic lab=vnxor_4_5
}
C {/media/sf_share/final_project/and5.sym} 5192.5 -875 0 0 {name=x53}
C {devices/vdd.sym} 5827.5 -1085 0 0 {name=l268 lab=VDD}
C {devices/vdd.sym} 5042.5 -835 3 0 {name=l269 lab=VDD}
C {devices/ammeter.sym} 5907.5 -132.5 0 0 {name=Vmeas_bump_6}
C {devices/vdd.sym} 5907.5 -222.5 0 0 {name=l270 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5952.5 417.5 0 1 {name=M49
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 6042.5 327.5 0 0 {name=M50
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 5932.5 447.5 0 0 {name=l271 lab=GND}
C {devices/vdd.sym} 6062.5 297.5 0 0 {name=l272 lab=VDD}
C {devices/ammeter.sym} 6062.5 497.5 0 0 {name=Vmeas_in_5}
C {/media/sf_share/final_project/nxor.sym} 4755 10 0 0 {name=x54}
C {devices/lab_pin.sym} 4605 0 0 0 {name=l273 sig_type=std_logic lab=vmem_1_6
}
C {devices/lab_pin.sym} 4605 20 2 1 {name=l274 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 5410 97.5 1 0 {name=l275 sig_type=std_logic lab=vand_6
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5647.5 -72.5 0 1 {name=M51
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5447.5 97.5 0 0 {name=M52
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5607.5 97.5 0 0 {name=M53
L=1
W=0.5
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5807.5 -72.5 0 1 {name=M54
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5647.5 207.5 0 1 {name=M55
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5627.5 -222.5 0 0 {name=l276 lab=VDD}
C {devices/gnd.sym} 5627.5 237.5 0 0 {name=l277 lab=GND}
C {devices/lab_pin.sym} 5667.5 207.5 0 1 {name=l278 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 5467.5 67.5 0 0 {name=l279 lab=VDD}
C {devices/vdd.sym} 5787.5 -102.5 0 0 {name=l280 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5647.5 -192.5 0 1 {name=M56
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5887.5 -192.5 0 0 {name=M57
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 4797.5 0 2 0 {name=l281 sig_type=std_logic lab=vnxor_1_6
}
C {/media/sf_share/final_project/nxor.sym} 4755 97.5 0 0 {name=x55}
C {devices/lab_pin.sym} 4605 87.5 0 0 {name=l282 sig_type=std_logic lab=vmem_2_6
}
C {devices/lab_pin.sym} 4605 107.5 2 1 {name=l283 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 4797.5 87.5 2 0 {name=l284 sig_type=std_logic lab=vnxor_2_6
}
C {/media/sf_share/final_project/nxor.sym} 4755 180 0 0 {name=x56}
C {devices/lab_pin.sym} 4605 170 0 0 {name=l285 sig_type=std_logic lab=vmem_3_6
}
C {devices/lab_pin.sym} 4605 190 2 1 {name=l286 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 4797.5 170 2 0 {name=l287 sig_type=std_logic lab=vnxor_3_6
}
C {/media/sf_share/final_project/nxor.sym} 4755 257.5 0 0 {name=x57}
C {devices/lab_pin.sym} 4605 247.5 0 0 {name=l288 sig_type=std_logic lab=vmem_4_6
}
C {devices/lab_pin.sym} 4605 267.5 2 1 {name=l289 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 4797.5 247.5 2 0 {name=l290 sig_type=std_logic lab=vnxor_4_6
}
C {/media/sf_share/final_project/and5.sym} 5192.5 137.5 0 0 {name=x58}
C {devices/vdd.sym} 5827.5 -72.5 0 0 {name=l292 lab=VDD}
C {devices/vdd.sym} 5042.5 177.5 3 0 {name=l293 lab=VDD}
C {/media/sf_share/final_project/cap_mem.sym} 3652.5 -3370 0 0 {name=x59}
C {devices/lab_pin.sym} 3502.5 -3350 0 0 {name=l294 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3732.5 -3410 0 1 {name=l295 sig_type=std_logic lab=vmem_1_5
}
C {devices/lab_pin.sym} 3577.5 -3300 3 0 {name=l296 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3600 -3300 3 0 {name=l297 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3502.5 -3390 2 1 {name=l298 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 3502.5 -3410 2 1 {name=l299 sig_type=std_logic lab=vg_5

}
C {/media/sf_share/final_project/cap_mem.sym} 3652.5 -3180 0 0 {name=x60}
C {devices/lab_pin.sym} 3502.5 -3160 0 0 {name=l300 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3732.5 -3220 0 1 {name=l301 sig_type=std_logic lab=vmem_2_5
}
C {devices/lab_pin.sym} 3577.5 -3110 3 0 {name=l302 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3600 -3110 3 0 {name=l303 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3502.5 -3200 2 1 {name=l304 sig_type=std_logic lab=vspike_2

}
C {/media/sf_share/final_project/cap_mem.sym} 3652.5 -2990 0 0 {name=x61}
C {devices/lab_pin.sym} 3502.5 -2970 0 0 {name=l305 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3732.5 -3030 0 1 {name=l306 sig_type=std_logic lab=vmem_3_5
}
C {devices/lab_pin.sym} 3577.5 -2920 3 0 {name=l307 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3600 -2920 3 0 {name=l308 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3502.5 -3010 2 1 {name=l309 sig_type=std_logic lab=vspike_3

}
C {/media/sf_share/final_project/cap_mem.sym} 3652.5 -2800 0 0 {name=x62}
C {devices/lab_pin.sym} 3502.5 -2780 0 0 {name=l310 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3732.5 -2840 0 1 {name=l311 sig_type=std_logic lab=vmem_4_5
}
C {devices/lab_pin.sym} 3577.5 -2730 3 0 {name=l312 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3600 -2730 3 0 {name=l313 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3502.5 -2820 2 1 {name=l314 sig_type=std_logic lab=vspike_4

}
C {/media/sf_share/final_project/cap_mem.sym} 4132.5 -3370 0 0 {name=x63}
C {devices/lab_pin.sym} 3982.5 -3350 0 0 {name=l315 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 4212.5 -3410 0 1 {name=l316 sig_type=std_logic lab=vmem_1_6
}
C {devices/lab_pin.sym} 4057.5 -3300 3 0 {name=l317 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 4080 -3300 3 0 {name=l318 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3982.5 -3390 2 1 {name=l319 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 3982.5 -3410 2 1 {name=l320 sig_type=std_logic lab=vg_6

}
C {/media/sf_share/final_project/cap_mem.sym} 4132.5 -3180 0 0 {name=x64}
C {devices/lab_pin.sym} 3982.5 -3160 0 0 {name=l321 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 4212.5 -3220 0 1 {name=l322 sig_type=std_logic lab=vmem_2_6
}
C {devices/lab_pin.sym} 4057.5 -3110 3 0 {name=l323 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 4080 -3110 3 0 {name=l324 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3982.5 -3200 2 1 {name=l325 sig_type=std_logic lab=vspike_2

}
C {/media/sf_share/final_project/cap_mem.sym} 4132.5 -2990 0 0 {name=x65}
C {devices/lab_pin.sym} 3982.5 -2970 0 0 {name=l326 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 4212.5 -3030 0 1 {name=l327 sig_type=std_logic lab=vmem_3_6
}
C {devices/lab_pin.sym} 4057.5 -2920 3 0 {name=l328 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 4080 -2920 3 0 {name=l329 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3982.5 -3010 2 1 {name=l330 sig_type=std_logic lab=vspike_3

}
C {/media/sf_share/final_project/cap_mem.sym} 4132.5 -2800 0 0 {name=x66}
C {devices/lab_pin.sym} 3982.5 -2780 0 0 {name=l331 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 4212.5 -2840 0 1 {name=l332 sig_type=std_logic lab=vmem_4_6
}
C {devices/lab_pin.sym} 4057.5 -2730 3 0 {name=l333 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 4080 -2730 3 0 {name=l334 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3982.5 -2820 2 1 {name=l335 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 3502.5 -3220 2 1 {name=l336 sig_type=std_logic lab=vg_5

}
C {devices/lab_pin.sym} 3502.5 -3030 2 1 {name=l337 sig_type=std_logic lab=vg_5

}
C {devices/lab_pin.sym} 3502.5 -2840 2 1 {name=l338 sig_type=std_logic lab=vg_5

}
C {devices/lab_pin.sym} 3982.5 -3220 2 1 {name=l339 sig_type=std_logic lab=vg_6

}
C {devices/lab_pin.sym} 3982.5 -3030 2 1 {name=l340 sig_type=std_logic lab=vg_6

}
C {devices/lab_pin.sym} 3982.5 -2840 2 1 {name=l341 sig_type=std_logic lab=vg_6

}
C {/media/sf_share/final_project/buffer.sym} 3735 -1770 0 0 {name=x67}
C {devices/lab_pin.sym} 3860 -1050 0 1 {name=l342 sig_type=std_logic lab=vout_2}
C {/media/sf_share/final_project/buffer.sym} 3740 -970 0 0 {name=x68}
C {devices/lab_pin.sym} 3860 -110 0 1 {name=l76 sig_type=std_logic lab=vout_3}
C {/media/sf_share/final_project/buffer.sym} 3740 -30 0 0 {name=x69}
C {devices/lab_pin.sym} 6067.5 -1875 0 1 {name=l181 sig_type=std_logic lab=vout_4}
C {/media/sf_share/final_project/buffer.sym} 5947.5 -1795 0 0 {name=x70}
C {devices/lab_pin.sym} 6067.5 -815 0 1 {name=l205 sig_type=std_logic lab=vout_5}
C {/media/sf_share/final_project/buffer.sym} 5947.5 -735 0 0 {name=x71}
C {devices/lab_pin.sym} 6067.5 167.5 0 1 {name=l267 sig_type=std_logic lab=vout_6}
C {/media/sf_share/final_project/buffer.sym} 5947.5 247.5 0 0 {name=x72}
C {devices/ammeter.sym} 495 -342.5 0 0 {name=Vmeas}
