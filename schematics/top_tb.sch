v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 3855 -3637.5 3855 -3587.5 { lab=#net1}
N 3655 -3667.5 3815 -3667.5 { lab=vspike_1}
N 3895 -3837.5 4055 -3837.5 { lab=vmem_1_1}
N 3695 -3637.5 4015 -3637.5 { lab=#net1}
N 4015 -3807.5 4015 -3637.5 { lab=#net1}
N 3895 -3957.5 4065 -3957.5 { lab=#net2}
N 3855 -3927.5 3985 -3927.5 { lab=#net2}
N 3985 -3957.5 3985 -3927.5 { lab=#net2}
N 2972.5 -2945 2972.5 -2885 { lab=#net3}
N 2972.5 -2945 3062.5 -2945 { lab=#net3}
N 3012.5 -2855 3102.5 -2855 { lab=#net4}
N 3102.5 -2915 3102.5 -2805 { lab=#net4}
N 2772.5 -2685 3102.5 -2685 { lab=#net4}
N 2942.5 -2685 2942.5 -2665 { lab=#net4}
N 3855 -3927.5 3855 -3867.5 { lab=#net2}
N 3855 -3807.5 3855 -3697.5 { lab=#net5}
N 3102.5 -2745 3102.5 -2685 { lab=#net4}
N 2942.5 -2605 2942.5 -2585 { lab=#net4}
N 1605 -2485 1635 -2485 { lab=LPbias2}
N 1605 -2445 1635 -2445 { lab=LPbias1}
N 1475 -2485 1475 -2465 { lab=#net6}
N 1475 -2465 1635 -2465 { lab=#net6}
N 1605 -2375 1635 -2375 { lab=LPbias2}
N 1605 -2335 1635 -2335 { lab=LPbias1}
N 1475 -2375 1475 -2355 { lab=#net7}
N 1475 -2355 1635 -2355 { lab=#net7}
N 1605 -2275 1635 -2275 { lab=LPbias2}
N 1605 -2235 1635 -2235 { lab=LPbias1}
N 1475 -2275 1475 -2255 { lab=#net8}
N 1475 -2255 1635 -2255 { lab=#net8}
N 1605 -2175 1635 -2175 { lab=LPbias2}
N 1605 -2135 1635 -2135 { lab=LPbias1}
N 1475 -2175 1475 -2155 { lab=#net9}
N 1475 -2155 1635 -2155 { lab=#net9}
N 4105 -3867.5 4105 -3660 { lab=#net10}
N 2397.5 -2945 2397.5 -2885 { lab=WTAin_1}
N 2397.5 -2945 2487.5 -2945 { lab=WTAin_1}
N 2437.5 -2855 2527.5 -2855 { lab=#net11}
N 2527.5 -2915 2527.5 -2805 { lab=#net11}
N 2527.5 -2745 2527.5 -2685 { lab=#net4}
N 2397.5 -3025 2397.5 -2945 { lab=WTAin_1}
N 2150 -2945 2150 -2885 { lab=WTAin_2}
N 2150 -2945 2240 -2945 { lab=WTAin_2}
N 2190 -2855 2280 -2855 { lab=#net12}
N 2280 -2915 2280 -2805 { lab=#net12}
N 2280 -2745 2280 -2685 { lab=#net4}
N 2150 -3025 2150 -2945 { lab=WTAin_2}
N 1897.5 -2945 1897.5 -2885 { lab=WTAin_3}
N 1897.5 -2945 1987.5 -2945 { lab=WTAin_3}
N 1937.5 -2855 2027.5 -2855 { lab=#net13}
N 2027.5 -2915 2027.5 -2805 { lab=#net13}
N 2027.5 -2745 2027.5 -2685 { lab=#net4}
N 1897.5 -3025 1897.5 -2945 { lab=WTAin_3}
N 1637.5 -2945 1637.5 -2885 { lab=WTAin_4}
N 1637.5 -2945 1727.5 -2945 { lab=WTAin_4}
N 1677.5 -2855 1767.5 -2855 { lab=#net14}
N 1767.5 -2915 1767.5 -2805 { lab=#net14}
N 1767.5 -2745 1767.5 -2685 { lab=#net4}
N 1637.5 -3025 1637.5 -2945 { lab=WTAin_4}
N 1372.5 -2945 1372.5 -2885 { lab=WTAin_5}
N 1372.5 -2945 1462.5 -2945 { lab=WTAin_5}
N 1412.5 -2855 1502.5 -2855 { lab=#net15}
N 1502.5 -2915 1502.5 -2805 { lab=#net15}
N 1502.5 -2745 1502.5 -2685 { lab=#net4}
N 1372.5 -3025 1372.5 -2945 { lab=WTAin_5}
N 1502.5 -2685 2772.5 -2685 { lab=#net4}
N 1115 -2945 1115 -2885 { lab=WTAin_6}
N 1115 -2945 1205 -2945 { lab=WTAin_6}
N 1155 -2855 1245 -2855 { lab=#net16}
N 1245 -2915 1245 -2805 { lab=#net16}
N 1245 -2745 1245 -2685 { lab=#net4}
N 1115 -3025 1115 -2945 { lab=WTAin_6}
N 1245 -2685 1502.5 -2685 { lab=#net4}
N 4415 -3637.5 4415 -3587.5 { lab=#net17}
N 4215 -3667.5 4375 -3667.5 { lab=vspike_2}
N 4455 -3837.5 4615 -3837.5 { lab=vmem_2_1}
N 4255 -3637.5 4575 -3637.5 { lab=#net17}
N 4575 -3807.5 4575 -3637.5 { lab=#net17}
N 4455 -3957.5 4625 -3957.5 { lab=#net18}
N 4415 -3927.5 4545 -3927.5 { lab=#net18}
N 4545 -3957.5 4545 -3927.5 { lab=#net18}
N 4415 -3927.5 4415 -3867.5 { lab=#net18}
N 4415 -3807.5 4415 -3697.5 { lab=#net19}
N 4665 -3867.5 4665 -3660 { lab=#net20}
N 4975 -3637.5 4975 -3587.5 { lab=#net21}
N 4775 -3667.5 4935 -3667.5 { lab=vspike_3}
N 5015 -3837.5 5175 -3837.5 { lab=vmem_3_1}
N 4815 -3637.5 5135 -3637.5 { lab=#net21}
N 5135 -3807.5 5135 -3637.5 { lab=#net21}
N 5015 -3957.5 5185 -3957.5 { lab=#net22}
N 4975 -3927.5 5105 -3927.5 { lab=#net22}
N 5105 -3957.5 5105 -3927.5 { lab=#net22}
N 4975 -3927.5 4975 -3867.5 { lab=#net22}
N 4975 -3807.5 4975 -3697.5 { lab=#net23}
N 5225 -3867.5 5225 -3660 { lab=#net24}
N 5535 -3637.5 5535 -3587.5 { lab=#net25}
N 5335 -3667.5 5495 -3667.5 { lab=vspike_4}
N 5575 -3837.5 5735 -3837.5 { lab=vmem_4_1}
N 5375 -3637.5 5695 -3637.5 { lab=#net25}
N 5695 -3807.5 5695 -3637.5 { lab=#net25}
N 5575 -3957.5 5745 -3957.5 { lab=#net26}
N 5535 -3927.5 5665 -3927.5 { lab=#net26}
N 5665 -3957.5 5665 -3927.5 { lab=#net26}
N 5535 -3927.5 5535 -3867.5 { lab=#net26}
N 5535 -3807.5 5535 -3697.5 { lab=#net27}
N 5785 -3867.5 5785 -3660 { lab=#net28}
N 4105 -3440 5785 -3440 { lab=WTAin_1}
N 3855 -3037.5 3855 -2987.5 { lab=#net29}
N 3655 -3067.5 3815 -3067.5 { lab=vspike_1}
N 3895 -3237.5 4055 -3237.5 { lab=vmem_1_2}
N 3695 -3037.5 4015 -3037.5 { lab=#net29}
N 4015 -3207.5 4015 -3037.5 { lab=#net29}
N 3895 -3357.5 4065 -3357.5 { lab=#net30}
N 3855 -3327.5 3985 -3327.5 { lab=#net30}
N 3985 -3357.5 3985 -3327.5 { lab=#net30}
N 3855 -3327.5 3855 -3267.5 { lab=#net30}
N 3855 -3207.5 3855 -3097.5 { lab=#net31}
N 4105 -3267.5 4105 -3060 { lab=WTAin_2}
N 4105 -3060 4105 -2840 { lab=WTAin_2}
N 4415 -3037.5 4415 -2987.5 { lab=#net32}
N 4215 -3067.5 4375 -3067.5 { lab=vspike_2}
N 4455 -3237.5 4615 -3237.5 { lab=vmem_2_2}
N 4255 -3037.5 4575 -3037.5 { lab=#net32}
N 4575 -3207.5 4575 -3037.5 { lab=#net32}
N 4455 -3357.5 4625 -3357.5 { lab=#net33}
N 4415 -3327.5 4545 -3327.5 { lab=#net33}
N 4545 -3357.5 4545 -3327.5 { lab=#net33}
N 4415 -3327.5 4415 -3267.5 { lab=#net33}
N 4415 -3207.5 4415 -3097.5 { lab=#net34}
N 4665 -3267.5 4665 -3060 { lab=WTAin_2}
N 4665 -3060 4665 -2840 { lab=WTAin_2}
N 4975 -3037.5 4975 -2987.5 { lab=#net35}
N 4775 -3067.5 4935 -3067.5 { lab=vspike_3}
N 5015 -3237.5 5175 -3237.5 { lab=vmem_3_2}
N 4815 -3037.5 5135 -3037.5 { lab=#net35}
N 5135 -3207.5 5135 -3037.5 { lab=#net35}
N 5015 -3357.5 5185 -3357.5 { lab=#net36}
N 4975 -3327.5 5105 -3327.5 { lab=#net36}
N 5105 -3357.5 5105 -3327.5 { lab=#net36}
N 4975 -3327.5 4975 -3267.5 { lab=#net36}
N 4975 -3207.5 4975 -3097.5 { lab=#net37}
N 5225 -3267.5 5225 -3060 { lab=WTAin_2}
N 5225 -3060 5225 -2840 { lab=WTAin_2}
N 5535 -3037.5 5535 -2987.5 { lab=#net38}
N 5335 -3067.5 5495 -3067.5 { lab=vspike_4}
N 5575 -3237.5 5735 -3237.5 { lab=vmem_4_2}
N 5375 -3037.5 5695 -3037.5 { lab=#net38}
N 5695 -3207.5 5695 -3037.5 { lab=#net38}
N 5575 -3357.5 5745 -3357.5 { lab=#net39}
N 5535 -3327.5 5665 -3327.5 { lab=#net39}
N 5665 -3357.5 5665 -3327.5 { lab=#net39}
N 5535 -3327.5 5535 -3267.5 { lab=#net39}
N 5535 -3207.5 5535 -3097.5 { lab=#net40}
N 5785 -3267.5 5785 -3060 { lab=WTAin_2}
N 5785 -3060 5785 -2840 { lab=WTAin_2}
N 4105 -2840 5785 -2840 { lab=WTAin_2}
N 3855 -2437.5 3855 -2387.5 { lab=#net41}
N 3655 -2467.5 3815 -2467.5 { lab=vspike_1}
N 3895 -2637.5 4055 -2637.5 { lab=vmem_1_3}
N 3695 -2437.5 4015 -2437.5 { lab=#net41}
N 4015 -2607.5 4015 -2437.5 { lab=#net41}
N 3895 -2757.5 4065 -2757.5 { lab=#net42}
N 3855 -2727.5 3985 -2727.5 { lab=#net42}
N 3985 -2757.5 3985 -2727.5 { lab=#net42}
N 3855 -2727.5 3855 -2667.5 { lab=#net42}
N 3855 -2607.5 3855 -2497.5 { lab=#net43}
N 4105 -2667.5 4105 -2460 { lab=WTAin_3}
N 4105 -2460 4105 -2240 { lab=WTAin_3}
N 4415 -2437.5 4415 -2387.5 { lab=#net44}
N 4215 -2467.5 4375 -2467.5 { lab=vspike_2}
N 4455 -2637.5 4615 -2637.5 { lab=vmem_2_3}
N 4255 -2437.5 4575 -2437.5 { lab=#net44}
N 4575 -2607.5 4575 -2437.5 { lab=#net44}
N 4455 -2757.5 4625 -2757.5 { lab=#net45}
N 4415 -2727.5 4545 -2727.5 { lab=#net45}
N 4545 -2757.5 4545 -2727.5 { lab=#net45}
N 4415 -2727.5 4415 -2667.5 { lab=#net45}
N 4415 -2607.5 4415 -2497.5 { lab=#net46}
N 4665 -2667.5 4665 -2460 { lab=WTAin_3}
N 4665 -2460 4665 -2240 { lab=WTAin_3}
N 4975 -2437.5 4975 -2387.5 { lab=#net47}
N 4775 -2467.5 4935 -2467.5 { lab=vspike_3}
N 5015 -2637.5 5175 -2637.5 { lab=vmem_3_3}
N 4815 -2437.5 5135 -2437.5 { lab=#net47}
N 5135 -2607.5 5135 -2437.5 { lab=#net47}
N 5015 -2757.5 5185 -2757.5 { lab=#net48}
N 4975 -2727.5 5105 -2727.5 { lab=#net48}
N 5105 -2757.5 5105 -2727.5 { lab=#net48}
N 4975 -2727.5 4975 -2667.5 { lab=#net48}
N 4975 -2607.5 4975 -2497.5 { lab=#net49}
N 5225 -2667.5 5225 -2460 { lab=WTAin_3}
N 5225 -2460 5225 -2240 { lab=WTAin_3}
N 5535 -2437.5 5535 -2387.5 { lab=#net50}
N 5335 -2467.5 5495 -2467.5 { lab=vspike_4}
N 5575 -2637.5 5735 -2637.5 { lab=vmem_4_3}
N 5375 -2437.5 5695 -2437.5 { lab=#net50}
N 5695 -2607.5 5695 -2437.5 { lab=#net50}
N 5575 -2757.5 5745 -2757.5 { lab=#net51}
N 5535 -2727.5 5665 -2727.5 { lab=#net51}
N 5665 -2757.5 5665 -2727.5 { lab=#net51}
N 5535 -2727.5 5535 -2667.5 { lab=#net51}
N 5535 -2607.5 5535 -2497.5 { lab=#net52}
N 5785 -2667.5 5785 -2460 { lab=WTAin_3}
N 5785 -2460 5785 -2240 { lab=WTAin_3}
N 4105 -2240 5785 -2240 { lab=WTAin_3}
N 3855 -1837.5 3855 -1787.5 { lab=#net53}
N 3655 -1867.5 3815 -1867.5 { lab=vspike_1}
N 3895 -2037.5 4055 -2037.5 { lab=vmem_1_4}
N 3695 -1837.5 4015 -1837.5 { lab=#net53}
N 4015 -2007.5 4015 -1837.5 { lab=#net53}
N 3895 -2157.5 4065 -2157.5 { lab=#net54}
N 3855 -2127.5 3985 -2127.5 { lab=#net54}
N 3985 -2157.5 3985 -2127.5 { lab=#net54}
N 3855 -2127.5 3855 -2067.5 { lab=#net54}
N 3855 -2007.5 3855 -1897.5 { lab=#net55}
N 4105 -2067.5 4105 -1860 { lab=WTAin_4}
N 4105 -1860 4105 -1640 { lab=WTAin_4}
N 4415 -1837.5 4415 -1787.5 { lab=#net56}
N 4215 -1867.5 4375 -1867.5 { lab=vspike_2}
N 4455 -2037.5 4615 -2037.5 { lab=vmem_2_4}
N 4255 -1837.5 4575 -1837.5 { lab=#net56}
N 4575 -2007.5 4575 -1837.5 { lab=#net56}
N 4455 -2157.5 4625 -2157.5 { lab=#net57}
N 4415 -2127.5 4545 -2127.5 { lab=#net57}
N 4545 -2157.5 4545 -2127.5 { lab=#net57}
N 4415 -2127.5 4415 -2067.5 { lab=#net57}
N 4415 -2007.5 4415 -1897.5 { lab=#net58}
N 4665 -2067.5 4665 -1860 { lab=WTAin_4}
N 4665 -1860 4665 -1640 { lab=WTAin_4}
N 4975 -1837.5 4975 -1787.5 { lab=#net59}
N 4775 -1867.5 4935 -1867.5 { lab=vspike_3}
N 5015 -2037.5 5175 -2037.5 { lab=vmem_3_4}
N 4815 -1837.5 5135 -1837.5 { lab=#net59}
N 5135 -2007.5 5135 -1837.5 { lab=#net59}
N 5015 -2157.5 5185 -2157.5 { lab=#net60}
N 4975 -2127.5 5105 -2127.5 { lab=#net60}
N 5105 -2157.5 5105 -2127.5 { lab=#net60}
N 4975 -2127.5 4975 -2067.5 { lab=#net60}
N 4975 -2007.5 4975 -1897.5 { lab=#net61}
N 5225 -2067.5 5225 -1860 { lab=WTAin_4}
N 5225 -1860 5225 -1640 { lab=WTAin_4}
N 5535 -1837.5 5535 -1787.5 { lab=#net62}
N 5335 -1867.5 5495 -1867.5 { lab=vspike_4}
N 5575 -2037.5 5735 -2037.5 { lab=vmem_4_4}
N 5375 -1837.5 5695 -1837.5 { lab=#net62}
N 5695 -2007.5 5695 -1837.5 { lab=#net62}
N 5575 -2157.5 5745 -2157.5 { lab=#net63}
N 5535 -2127.5 5665 -2127.5 { lab=#net63}
N 5665 -2157.5 5665 -2127.5 { lab=#net63}
N 5535 -2127.5 5535 -2067.5 { lab=#net63}
N 5535 -2007.5 5535 -1897.5 { lab=#net64}
N 5785 -2067.5 5785 -1860 { lab=WTAin_4}
N 5785 -1860 5785 -1640 { lab=WTAin_4}
N 4105 -1640 5785 -1640 { lab=WTAin_4}
N 3855 -1227.5 3855 -1177.5 { lab=#net65}
N 3655 -1257.5 3815 -1257.5 { lab=vspike_1}
N 3895 -1427.5 4055 -1427.5 { lab=vmem_1_5}
N 3695 -1227.5 4015 -1227.5 { lab=#net65}
N 4015 -1397.5 4015 -1227.5 { lab=#net65}
N 3895 -1547.5 4065 -1547.5 { lab=#net66}
N 3855 -1517.5 3985 -1517.5 { lab=#net66}
N 3985 -1547.5 3985 -1517.5 { lab=#net66}
N 3855 -1517.5 3855 -1457.5 { lab=#net66}
N 3855 -1397.5 3855 -1287.5 { lab=#net67}
N 4105 -1457.5 4105 -1250 { lab=WTAin_5}
N 4105 -1250 4105 -1030 { lab=WTAin_5}
N 4415 -1227.5 4415 -1177.5 { lab=#net68}
N 4215 -1257.5 4375 -1257.5 { lab=vspike_2}
N 4455 -1427.5 4615 -1427.5 { lab=vmem_2_5}
N 4255 -1227.5 4575 -1227.5 { lab=#net68}
N 4575 -1397.5 4575 -1227.5 { lab=#net68}
N 4455 -1547.5 4625 -1547.5 { lab=#net69}
N 4415 -1517.5 4545 -1517.5 { lab=#net69}
N 4545 -1547.5 4545 -1517.5 { lab=#net69}
N 4415 -1517.5 4415 -1457.5 { lab=#net69}
N 4415 -1397.5 4415 -1287.5 { lab=#net70}
N 4665 -1457.5 4665 -1250 { lab=WTAin_5}
N 4665 -1250 4665 -1030 { lab=WTAin_5}
N 4975 -1227.5 4975 -1177.5 { lab=#net71}
N 4775 -1257.5 4935 -1257.5 { lab=vspike_3}
N 5015 -1427.5 5175 -1427.5 { lab=vmem_3_5}
N 4815 -1227.5 5135 -1227.5 { lab=#net71}
N 5135 -1397.5 5135 -1227.5 { lab=#net71}
N 5015 -1547.5 5185 -1547.5 { lab=#net72}
N 4975 -1517.5 5105 -1517.5 { lab=#net72}
N 5105 -1547.5 5105 -1517.5 { lab=#net72}
N 4975 -1517.5 4975 -1457.5 { lab=#net72}
N 4975 -1397.5 4975 -1287.5 { lab=#net73}
N 5225 -1457.5 5225 -1250 { lab=WTAin_5}
N 5225 -1250 5225 -1030 { lab=WTAin_5}
N 5535 -1227.5 5535 -1177.5 { lab=#net74}
N 5335 -1257.5 5495 -1257.5 { lab=vspike_4}
N 5575 -1427.5 5735 -1427.5 { lab=vmem_4_5}
N 5375 -1227.5 5695 -1227.5 { lab=#net74}
N 5695 -1397.5 5695 -1227.5 { lab=#net74}
N 5575 -1547.5 5745 -1547.5 { lab=#net75}
N 5535 -1517.5 5665 -1517.5 { lab=#net75}
N 5665 -1547.5 5665 -1517.5 { lab=#net75}
N 5535 -1517.5 5535 -1457.5 { lab=#net75}
N 5535 -1397.5 5535 -1287.5 { lab=#net76}
N 5785 -1457.5 5785 -1250 { lab=WTAin_5}
N 5785 -1250 5785 -1030 { lab=WTAin_5}
N 4105 -1030 5785 -1030 { lab=WTAin_5}
N 3855 -627.5 3855 -577.5 { lab=#net77}
N 3655 -657.5 3815 -657.5 { lab=vspike_1}
N 3895 -827.5 4055 -827.5 { lab=vmem_1_6}
N 3695 -627.5 4015 -627.5 { lab=#net77}
N 4015 -797.5 4015 -627.5 { lab=#net77}
N 3895 -947.5 4065 -947.5 { lab=#net78}
N 3855 -917.5 3985 -917.5 { lab=#net78}
N 3985 -947.5 3985 -917.5 { lab=#net78}
N 3855 -917.5 3855 -857.5 { lab=#net78}
N 3855 -797.5 3855 -687.5 { lab=#net79}
N 4105 -857.5 4105 -650 { lab=WTAin_6}
N 4105 -650 4105 -430 { lab=WTAin_6}
N 4415 -627.5 4415 -577.5 { lab=#net80}
N 4215 -657.5 4375 -657.5 { lab=vspike_2}
N 4455 -827.5 4615 -827.5 { lab=vmem_2_6}
N 4255 -627.5 4575 -627.5 { lab=#net80}
N 4575 -797.5 4575 -627.5 { lab=#net80}
N 4455 -947.5 4625 -947.5 { lab=#net81}
N 4415 -917.5 4545 -917.5 { lab=#net81}
N 4545 -947.5 4545 -917.5 { lab=#net81}
N 4415 -917.5 4415 -857.5 { lab=#net81}
N 4415 -797.5 4415 -687.5 { lab=#net82}
N 4665 -857.5 4665 -650 { lab=WTAin_6}
N 4665 -650 4665 -430 { lab=WTAin_6}
N 4975 -627.5 4975 -577.5 { lab=#net83}
N 4775 -657.5 4935 -657.5 { lab=vspike_3}
N 5015 -827.5 5175 -827.5 { lab=vmem_3_6}
N 4815 -627.5 5135 -627.5 { lab=#net83}
N 5135 -797.5 5135 -627.5 { lab=#net83}
N 5015 -947.5 5185 -947.5 { lab=#net84}
N 4975 -917.5 5105 -917.5 { lab=#net84}
N 5105 -947.5 5105 -917.5 { lab=#net84}
N 4975 -917.5 4975 -857.5 { lab=#net84}
N 4975 -797.5 4975 -687.5 { lab=#net85}
N 5225 -857.5 5225 -650 { lab=WTAin_6}
N 5225 -650 5225 -430 { lab=WTAin_6}
N 5535 -627.5 5535 -577.5 { lab=#net86}
N 5335 -657.5 5495 -657.5 { lab=vspike_4}
N 5575 -827.5 5735 -827.5 { lab=vmem_4_6}
N 5375 -627.5 5695 -627.5 { lab=#net86}
N 5695 -797.5 5695 -627.5 { lab=#net86}
N 5575 -947.5 5745 -947.5 { lab=#net87}
N 5535 -917.5 5665 -917.5 { lab=#net87}
N 5665 -947.5 5665 -917.5 { lab=#net87}
N 5535 -917.5 5535 -857.5 { lab=#net87}
N 5535 -797.5 5535 -687.5 { lab=#net88}
N 5785 -857.5 5785 -650 { lab=WTAin_6}
N 5785 -650 5785 -430 { lab=WTAin_6}
N 4105 -430 5785 -430 { lab=WTAin_6}
N 2397.5 -3100 2397.5 -3025 { lab=WTAin_1}
N 2150 -3100 2150 -3025 { lab=WTAin_2}
N 1897.5 -3100 1897.5 -3025 { lab=WTAin_3}
N 1637.5 -3100 1637.5 -3025 { lab=WTAin_4}
N 1372.5 -3100 1372.5 -3025 { lab=WTAin_5}
N 1115 -3100 1115 -3025 { lab=WTAin_6}
N 2942.5 -2665 2942.5 -2605 { lab=#net4}
N 3102.5 -2805 3102.5 -2745 { lab=#net4}
N 4105 -917.5 4105 -857.5 { lab=WTAin_6}
N 4665 -917.5 4665 -857.5 { lab=WTAin_6}
N 5225 -917.5 5225 -857.5 { lab=WTAin_6}
N 5785 -917.5 5785 -857.5 { lab=WTAin_6}
N 4105 -1517.5 4105 -1457.5 { lab=WTAin_5}
N 4665 -1517.5 4665 -1457.5 { lab=WTAin_5}
N 5225 -1517.5 5225 -1457.5 { lab=WTAin_5}
N 5785 -1517.5 5785 -1457.5 { lab=WTAin_5}
N 4105 -2127.5 4105 -2067.5 { lab=WTAin_4}
N 4665 -2127.5 4665 -2067.5 { lab=WTAin_4}
N 5225 -2127.5 5225 -2067.5 { lab=WTAin_4}
N 5785 -2127.5 5785 -2067.5 { lab=WTAin_4}
N 4105 -2727.5 4105 -2667.5 { lab=WTAin_3}
N 4665 -2727.5 4665 -2667.5 { lab=WTAin_3}
N 5225 -2727.5 5225 -2667.5 { lab=WTAin_3}
N 5785 -2727.5 5785 -2667.5 { lab=WTAin_3}
N 4105 -3327.5 4105 -3267.5 { lab=WTAin_2}
N 4665 -3327.5 4665 -3267.5 { lab=WTAin_2}
N 5225 -3327.5 5225 -3267.5 { lab=WTAin_2}
N 5785 -3327.5 5785 -3267.5 { lab=WTAin_2}
N 4105 -3927.5 4105 -3867.5 { lab=#net10}
N 4665 -3927.5 4665 -3867.5 { lab=#net20}
N 5225 -3927.5 5225 -3867.5 { lab=#net24}
N 5785 -3927.5 5785 -3867.5 { lab=#net28}
N 4105 -3660 4105 -3582.5 { lab=#net10}
N 4105 -3522.5 4105 -3440 { lab=WTAin_1}
N 4665 -3660 4665 -3582.5 { lab=#net20}
N 4665 -3522.5 4665 -3440 { lab=WTAin_1}
N 5225 -3660 5225 -3582.5 { lab=#net24}
N 5225 -3522.5 5225 -3440 { lab=WTAin_1}
N 5785 -3660 5785 -3582.5 { lab=#net28}
N 5785 -3522.5 5785 -3440 { lab=WTAin_1}
C {devices/gnd.sym} 1502.5 -455 0 0 {name=l1 lab=GND}
C {devices/vdd.sym} 1422.5 -515 0 0 {name=l8 lab=VDD}
C {devices/vsource.sym} 1422.5 -485 0 0 {name=V2 value=5.0}
C {devices/gnd.sym} 1422.5 -455 0 0 {name=l9 lab=GND}
C {devices/code.sym} 1122.5 -1067.5 0 0 {name=TT_MODELS only_toplevel=true
format="tcleval( @value )"
value=".lib \\\\$::SKYWATER_MODELS\\\\/models/sky130.lib.spice tt

.param mc_mm_switch=0
.param mc_pr_switch=1
"}
C {devices/vsource.sym} 1502.5 -485 0 0 {name=V5 value=0.4}
C {devices/lab_pin.sym} 1502.5 -515 3 1 {name=l17 sig_type=std_logic lab=HPbias

}
C {devices/gnd.sym} 1572.5 -455 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} 1572.5 -515 3 1 {name=l19 sig_type=std_logic lab=VREF

}
C {devices/vsource.sym} 1572.5 -485 0 0 {name=V6 value=2.0}
C {devices/vsource.sym} 1642.5 -485 0 0 {name=V3 value=0.543v}
C {devices/gnd.sym} 1642.5 -455 0 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} 1642.5 -515 3 1 {name=l15 sig_type=std_logic lab=LPbias1

}
C {devices/vsource.sym} 1712.5 -485 0 0 {name=V4 value=0.4v}
C {devices/gnd.sym} 1712.5 -455 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 1712.5 -515 3 1 {name=l21 sig_type=std_logic lab=LPbias2

}
C {devices/lab_pin.sym} 1240 -830 1 0 {name=l23 sig_type=std_logic lab=vbias}
C {devices/gnd.sym} 1240 -770 0 0 {name=l24 lab=GND}
C {devices/vsource.sym} 1240 -800 0 0 {name=Vbias value=1v}
C {devices/gnd.sym} 1332.5 -762.5 0 0 {name=l35 lab=GND}
C {devices/vsource.sym} 1332.5 -792.5 0 0 {name=Vbias2 value=0.32v}
C {devices/lab_pin.sym} 1332.5 -822.5 1 0 {name=l37 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 1475 -830 1 0 {name=l38 sig_type=std_logic lab=vbias1}
C {devices/gnd.sym} 1475 -770 0 0 {name=l39 lab=GND}
C {devices/vsource.sym} 1475 -800 0 0 {name=Vbias3 value=0.6v}
C {devices/lab_pin.sym} 1597.5 -832.5 1 0 {name=l40 sig_type=std_logic lab=vbias2}
C {devices/gnd.sym} 1597.5 -772.5 0 0 {name=l41 lab=GND}
C {devices/vsource.sym} 1597.5 -802.5 0 0 {name=Vbias4 value=1.1v}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -3837.5 0 1 {name=M3
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3675 -3667.5 0 0 {name=M4
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3835 -3667.5 0 0 {name=M6
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4035 -3837.5 0 1 {name=M7
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -3557.5 0 1 {name=M1
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 3855 -3987.5 0 0 {name=l46 lab=VDD}
C {devices/gnd.sym} 3855 -3527.5 0 0 {name=l47 lab=GND}
C {devices/lab_pin.sym} 4055 -3837.5 1 1 {name=l49 sig_type=std_logic lab=vmem_1_1}
C {devices/lab_pin.sym} 3895 -3557.5 0 1 {name=l50 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 3695 -3697.5 0 0 {name=l51 lab=VDD}
C {devices/vdd.sym} 4015 -3867.5 0 0 {name=l52 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4085 -3957.5 0 0 {name=M2
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3875 -3957.5 0 1 {name=M5
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4105 -3987.5 0 0 {name=l53 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 2992.5 -2855 0 1 {name=M10
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3082.5 -2945 0 0 {name=M11
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 2972.5 -2825 0 0 {name=l56 lab=GND}
C {devices/vdd.sym} 3102.5 -2975 0 0 {name=l57 lab=VDD}
C {devices/vdd.sym} 2972.5 -3005 0 0 {name=l58 lab=VDD}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 2922.5 -2555 0 0 {name=M12
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 2942.5 -2525 0 0 {name=l59 lab=GND}
C {devices/lab_pin.sym} 2902.5 -2555 0 0 {name=l60 sig_type=std_logic lab=vbias_WTA}
C {devices/lab_pin.sym} 1247.5 -515 1 0 {name=l61 sig_type=std_logic lab=vbias_bump}
C {devices/gnd.sym} 1247.5 -455 0 0 {name=l62 lab=GND}
C {devices/vsource.sym} 1247.5 -485 0 0 {name=Vbias5 value=1.2v}
C {devices/lab_pin.sym} 1167.5 -515 1 0 {name=l63 sig_type=std_logic lab=vbias_WTA}
C {devices/gnd.sym} 1167.5 -455 0 0 {name=l64 lab=GND}
C {devices/vsource.sym} 1167.5 -485 0 0 {name=Vbias6 value=1.5v}
C {devices/code_shown.sym} 2075 -1050 0 0 {name=SPICE only_toplevel=false value="
.model fsrc1 filesource(file=\\"data/eval_dataset/electrode_ch1.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a1 %v[vin_1] fsrc1
.model fsrc2 filesource(file=\\"data/eval_dataset/electrode_ch2.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a2 %v[vin_2] fsrc2
.model fsrc3 filesource(file=\\"data/eval_dataset/electrode_ch3.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a3 %v[vin_3] fsrc3
.model fsrc4 filesource(file=\\"data/eval_dataset/electrode_ch4.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a4 %v[vin_4] fsrc4
.model fsrc5 filesource(file=\\"data/eval_dataset/teach_ch1.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a5 %v[vg_1] fsrc5
.model fsrc6 filesource(file=\\"data/eval_dataset/teach_ch2.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a6 %v[vg_2] fsrc6
.model fsrc7 filesource(file=\\"data/eval_dataset/teach_ch3.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a7 %v[vg_3] fsrc7
.model fsrc8 filesource(file=\\"data/eval_dataset/teach_ch4.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a8 %v[vg_4] fsrc8
.model fsrc9 filesource(file=\\"data/eval_dataset/teach_ch5.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a9 %v[vg_5] fsrc9
.model fsrc10 filesource(file=\\"data/eval_dataset/teach_ch6.txt\\" timeoffset=0 timescale=1 amploffset=[0] amplscale=[1.0] timerelative=false amplstep=false) 
a10 %v[vg_6] fsrc10
.control
save all
tran 1000us 600ms uic
plot v(neuron_1) v(neuron_2) v(neuron_3) v(neuron_4) v(neuron_5) v(neuron_6)
.endc
"}
C {devices/lab_pin.sym} 1185 -2485 0 0 {name=l12 sig_type=std_logic lab=vin_1
}
C {/media/sf_share/Highpass_500Hz.sym} 1335 -2465 0 0 {name=x6}
C {devices/lab_pin.sym} 1185 -2465 2 1 {name=l20 sig_type=std_logic lab=HPbias

}
C {devices/lab_pin.sym} 1185 -2445 2 1 {name=l65 sig_type=std_logic lab=VREF

}
C {/media/sf_share/Lowpass_2500Hz.sym} 1785 -2465 0 0 {name=x7}
C {devices/lab_pin.sym} 1605 -2445 2 1 {name=l66 sig_type=std_logic lab=LPbias1

}
C {devices/lab_pin.sym} 1605 -2485 2 1 {name=l67 sig_type=std_logic lab=LPbias2

}
C {/media/sf_share/final_project/schmitt_trigger.sym} 2085 -2485 0 0 {name=x8}
C {devices/lab_pin.sym} 1935 -2485 3 0 {name=l68 sig_type=std_logic lab=vfilter_1

}
C {devices/lab_pin.sym} 2085 -2485 2 0 {name=l69 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 1185 -2375 0 0 {name=l70 sig_type=std_logic lab=vin_2
}
C {/media/sf_share/Highpass_500Hz.sym} 1335 -2355 0 0 {name=x9}
C {devices/lab_pin.sym} 1185 -2355 2 1 {name=l71 sig_type=std_logic lab=HPbias

}
C {devices/lab_pin.sym} 1185 -2335 2 1 {name=l72 sig_type=std_logic lab=VREF

}
C {/media/sf_share/Lowpass_2500Hz.sym} 1785 -2355 0 0 {name=x10}
C {devices/lab_pin.sym} 1605 -2335 2 1 {name=l73 sig_type=std_logic lab=LPbias1

}
C {devices/lab_pin.sym} 1605 -2375 2 1 {name=l74 sig_type=std_logic lab=LPbias2

}
C {/media/sf_share/final_project/schmitt_trigger.sym} 2085 -2375 0 0 {name=x11}
C {devices/lab_pin.sym} 2085 -2375 2 0 {name=l76 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 1185 -2275 0 0 {name=l77 sig_type=std_logic lab=vin_3
}
C {/media/sf_share/Highpass_500Hz.sym} 1335 -2255 0 0 {name=x12}
C {devices/lab_pin.sym} 1185 -2255 2 1 {name=l78 sig_type=std_logic lab=HPbias

}
C {devices/lab_pin.sym} 1185 -2235 2 1 {name=l79 sig_type=std_logic lab=VREF

}
C {/media/sf_share/Lowpass_2500Hz.sym} 1785 -2255 0 0 {name=x13}
C {devices/lab_pin.sym} 1605 -2235 2 1 {name=l80 sig_type=std_logic lab=LPbias1

}
C {devices/lab_pin.sym} 1605 -2275 2 1 {name=l81 sig_type=std_logic lab=LPbias2

}
C {/media/sf_share/final_project/schmitt_trigger.sym} 2085 -2275 0 0 {name=x14}
C {devices/lab_pin.sym} 2085 -2275 2 0 {name=l83 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 1185 -2175 0 0 {name=l84 sig_type=std_logic lab=vin_4
}
C {/media/sf_share/Highpass_500Hz.sym} 1335 -2155 0 0 {name=x15}
C {devices/lab_pin.sym} 1185 -2155 2 1 {name=l85 sig_type=std_logic lab=HPbias

}
C {devices/lab_pin.sym} 1185 -2135 2 1 {name=l86 sig_type=std_logic lab=VREF

}
C {/media/sf_share/Lowpass_2500Hz.sym} 1785 -2155 0 0 {name=x16}
C {devices/lab_pin.sym} 1605 -2135 2 1 {name=l87 sig_type=std_logic lab=LPbias1

}
C {devices/lab_pin.sym} 1605 -2175 2 1 {name=l88 sig_type=std_logic lab=LPbias2

}
C {/media/sf_share/final_project/schmitt_trigger.sym} 2085 -2175 0 0 {name=x17}
C {devices/lab_pin.sym} 2085 -2175 2 0 {name=l90 sig_type=std_logic lab=vspike_4

}
C {/media/sf_share/final_project/cap_mem.sym} 1335 -1930 0 0 {name=x18}
C {devices/lab_pin.sym} 1185 -1890 0 0 {name=l92 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 1185 -1910 0 0 {name=l93 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1415 -1970 0 1 {name=l94 sig_type=std_logic lab=vmem_1_1
}
C {devices/lab_pin.sym} 1260 -1860 3 0 {name=l95 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1282.5 -1860 3 0 {name=l96 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1185 -1950 2 1 {name=l97 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 1185 -1970 2 1 {name=l98 sig_type=std_logic lab=vg_1

}
C {devices/lab_pin.sym} 1935 -2375 3 0 {name=l2 sig_type=std_logic lab=vfilter_2

}
C {devices/lab_pin.sym} 1935 -2275 3 0 {name=l3 sig_type=std_logic lab=vfilter_3

}
C {devices/lab_pin.sym} 1935 -2175 3 0 {name=l5 sig_type=std_logic lab=vfilter_4

}
C {/media/sf_share/final_project/cap_mem.sym} 1335 -1740 0 0 {name=x1}
C {devices/lab_pin.sym} 1185 -1700 0 0 {name=l10 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 1185 -1720 0 0 {name=l11 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1415 -1780 0 1 {name=l13 sig_type=std_logic lab=vmem_2_1
}
C {devices/lab_pin.sym} 1260 -1670 3 0 {name=l75 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1282.5 -1670 3 0 {name=l82 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1185 -1760 2 1 {name=l89 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 1185 -1780 2 1 {name=l99 sig_type=std_logic lab=vg_1

}
C {/media/sf_share/final_project/cap_mem.sym} 1335 -1550 0 0 {name=x2}
C {devices/lab_pin.sym} 1185 -1510 0 0 {name=l101 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 1185 -1530 0 0 {name=l102 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1415 -1590 0 1 {name=l103 sig_type=std_logic lab=vmem_3_1
}
C {devices/lab_pin.sym} 1260 -1480 3 0 {name=l104 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1282.5 -1480 3 0 {name=l105 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1185 -1570 2 1 {name=l106 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 1185 -1590 2 1 {name=l107 sig_type=std_logic lab=vg_1

}
C {/media/sf_share/final_project/cap_mem.sym} 1335 -1360 0 0 {name=x3}
C {devices/lab_pin.sym} 1185 -1320 0 0 {name=l109 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 1185 -1340 0 0 {name=l110 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1415 -1400 0 1 {name=l111 sig_type=std_logic lab=vmem_4_1
}
C {devices/lab_pin.sym} 1260 -1290 3 0 {name=l112 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1282.5 -1290 3 0 {name=l113 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1185 -1380 2 1 {name=l114 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 1185 -1400 2 1 {name=l115 sig_type=std_logic lab=vg_1

}
C {/media/sf_share/final_project/cap_mem.sym} 1755 -1930 0 0 {name=x19}
C {devices/lab_pin.sym} 1605 -1890 0 0 {name=l117 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 1605 -1910 0 0 {name=l118 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1835 -1970 0 1 {name=l119 sig_type=std_logic lab=vmem_1_2
}
C {devices/lab_pin.sym} 1680 -1860 3 0 {name=l120 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1702.5 -1860 3 0 {name=l121 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1605 -1950 2 1 {name=l122 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 1605 -1970 2 1 {name=l123 sig_type=std_logic lab=vg_2

}
C {/media/sf_share/final_project/cap_mem.sym} 2175 -1930 0 0 {name=x20}
C {devices/lab_pin.sym} 2025 -1890 0 0 {name=l125 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2025 -1910 0 0 {name=l126 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2255 -1970 0 1 {name=l127 sig_type=std_logic lab=vmem_1_3
}
C {devices/lab_pin.sym} 2100 -1860 3 0 {name=l128 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2122.5 -1860 3 0 {name=l129 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2025 -1950 2 1 {name=l130 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 2025 -1970 2 1 {name=l131 sig_type=std_logic lab=vg_3

}
C {/media/sf_share/final_project/cap_mem.sym} 2595 -1930 0 0 {name=x21}
C {devices/lab_pin.sym} 2445 -1890 0 0 {name=l133 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2445 -1910 0 0 {name=l134 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2675 -1970 0 1 {name=l135 sig_type=std_logic lab=vmem_1_4
}
C {devices/lab_pin.sym} 2520 -1860 3 0 {name=l136 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2542.5 -1860 3 0 {name=l137 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2445 -1950 2 1 {name=l138 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 2445 -1970 2 1 {name=l139 sig_type=std_logic lab=vg_4

}
C {/media/sf_share/final_project/cap_mem.sym} 3015 -1930 0 0 {name=x22}
C {devices/lab_pin.sym} 2865 -1890 0 0 {name=l141 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2865 -1910 0 0 {name=l142 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3095 -1970 0 1 {name=l143 sig_type=std_logic lab=vmem_1_5
}
C {devices/lab_pin.sym} 2940 -1860 3 0 {name=l144 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2962.5 -1860 3 0 {name=l145 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2865 -1970 2 1 {name=l147 sig_type=std_logic lab=vg_5

}
C {/media/sf_share/final_project/cap_mem.sym} 3435 -1930 0 0 {name=x23}
C {devices/lab_pin.sym} 3285 -1890 0 0 {name=l149 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 3285 -1910 0 0 {name=l150 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3515 -1970 0 1 {name=l151 sig_type=std_logic lab=vmem_1_6
}
C {devices/lab_pin.sym} 3360 -1860 3 0 {name=l152 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3382.5 -1860 3 0 {name=l153 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3285 -1970 2 1 {name=l155 sig_type=std_logic lab=vg_6

}
C {/media/sf_share/final_project/cap_mem.sym} 1755 -1740 0 0 {name=x24}
C {devices/lab_pin.sym} 1605 -1700 0 0 {name=l157 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 1605 -1720 0 0 {name=l158 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1835 -1780 0 1 {name=l159 sig_type=std_logic lab=vmem_2_2
}
C {devices/lab_pin.sym} 1680 -1670 3 0 {name=l160 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1702.5 -1670 3 0 {name=l161 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1605 -1760 2 1 {name=l162 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 1605 -1780 2 1 {name=l163 sig_type=std_logic lab=vg_2

}
C {/media/sf_share/final_project/cap_mem.sym} 2175 -1740 0 0 {name=x25}
C {devices/lab_pin.sym} 2025 -1700 0 0 {name=l165 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2025 -1720 0 0 {name=l166 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2255 -1780 0 1 {name=l167 sig_type=std_logic lab=vmem_2_3
}
C {devices/lab_pin.sym} 2100 -1670 3 0 {name=l168 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2122.5 -1670 3 0 {name=l169 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2025 -1760 2 1 {name=l170 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 2025 -1780 2 1 {name=l171 sig_type=std_logic lab=vg_3

}
C {/media/sf_share/final_project/cap_mem.sym} 2595 -1740 0 0 {name=x26}
C {devices/lab_pin.sym} 2445 -1700 0 0 {name=l173 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2445 -1720 0 0 {name=l174 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2675 -1780 0 1 {name=l175 sig_type=std_logic lab=vmem_2_4
}
C {devices/lab_pin.sym} 2520 -1670 3 0 {name=l176 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2542.5 -1670 3 0 {name=l177 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2445 -1760 2 1 {name=l178 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 2445 -1780 2 1 {name=l179 sig_type=std_logic lab=vg_4

}
C {/media/sf_share/final_project/cap_mem.sym} 3015 -1740 0 0 {name=x27}
C {devices/lab_pin.sym} 2865 -1700 0 0 {name=l181 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2865 -1720 0 0 {name=l182 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3095 -1780 0 1 {name=l183 sig_type=std_logic lab=vmem_2_5
}
C {devices/lab_pin.sym} 2940 -1670 3 0 {name=l184 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2962.5 -1670 3 0 {name=l185 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2865 -1780 2 1 {name=l187 sig_type=std_logic lab=vg_5

}
C {/media/sf_share/final_project/cap_mem.sym} 3435 -1740 0 0 {name=x28}
C {devices/lab_pin.sym} 3285 -1700 0 0 {name=l189 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 3285 -1720 0 0 {name=l190 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3515 -1780 0 1 {name=l191 sig_type=std_logic lab=vmem_2_6
}
C {devices/lab_pin.sym} 3360 -1670 3 0 {name=l192 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3382.5 -1670 3 0 {name=l193 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3285 -1780 2 1 {name=l195 sig_type=std_logic lab=vg_6

}
C {/media/sf_share/final_project/cap_mem.sym} 1755 -1550 0 0 {name=x29}
C {devices/lab_pin.sym} 1605 -1510 0 0 {name=l197 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 1605 -1530 0 0 {name=l198 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1835 -1590 0 1 {name=l199 sig_type=std_logic lab=vmem_3_2
}
C {devices/lab_pin.sym} 1680 -1480 3 0 {name=l200 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1702.5 -1480 3 0 {name=l201 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1605 -1570 2 1 {name=l202 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 1605 -1590 2 1 {name=l203 sig_type=std_logic lab=vg_2

}
C {/media/sf_share/final_project/cap_mem.sym} 2175 -1550 0 0 {name=x30}
C {devices/lab_pin.sym} 2025 -1510 0 0 {name=l205 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2025 -1530 0 0 {name=l206 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2255 -1590 0 1 {name=l207 sig_type=std_logic lab=vmem_3_3
}
C {devices/lab_pin.sym} 2100 -1480 3 0 {name=l208 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2122.5 -1480 3 0 {name=l209 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2025 -1570 2 1 {name=l210 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 2025 -1590 2 1 {name=l211 sig_type=std_logic lab=vg_3

}
C {/media/sf_share/final_project/cap_mem.sym} 2595 -1550 0 0 {name=x31}
C {devices/lab_pin.sym} 2445 -1510 0 0 {name=l213 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2445 -1530 0 0 {name=l214 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2675 -1590 0 1 {name=l215 sig_type=std_logic lab=vmem_3_4
}
C {devices/lab_pin.sym} 2520 -1480 3 0 {name=l216 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2542.5 -1480 3 0 {name=l217 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2445 -1570 2 1 {name=l218 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 2445 -1590 2 1 {name=l219 sig_type=std_logic lab=vg_4

}
C {/media/sf_share/final_project/cap_mem.sym} 3015 -1550 0 0 {name=x32}
C {devices/lab_pin.sym} 2865 -1510 0 0 {name=l221 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2865 -1530 0 0 {name=l222 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3095 -1590 0 1 {name=l223 sig_type=std_logic lab=vmem_3_5
}
C {devices/lab_pin.sym} 2940 -1480 3 0 {name=l224 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2962.5 -1480 3 0 {name=l225 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2865 -1590 2 1 {name=l227 sig_type=std_logic lab=vg_5

}
C {/media/sf_share/final_project/cap_mem.sym} 3435 -1550 0 0 {name=x33}
C {devices/lab_pin.sym} 3285 -1510 0 0 {name=l229 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 3285 -1530 0 0 {name=l230 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3515 -1590 0 1 {name=l231 sig_type=std_logic lab=vmem_3_6
}
C {devices/lab_pin.sym} 3360 -1480 3 0 {name=l232 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3382.5 -1480 3 0 {name=l233 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3285 -1590 2 1 {name=l235 sig_type=std_logic lab=vg_6

}
C {/media/sf_share/final_project/cap_mem.sym} 1755 -1360 0 0 {name=x34}
C {devices/lab_pin.sym} 1605 -1320 0 0 {name=l237 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 1605 -1340 0 0 {name=l238 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 1835 -1400 0 1 {name=l239 sig_type=std_logic lab=vmem_4_2
}
C {devices/lab_pin.sym} 1680 -1290 3 0 {name=l240 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 1702.5 -1290 3 0 {name=l241 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 1605 -1380 2 1 {name=l242 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 1605 -1400 2 1 {name=l243 sig_type=std_logic lab=vg_2

}
C {/media/sf_share/final_project/cap_mem.sym} 2175 -1360 0 0 {name=x35}
C {devices/lab_pin.sym} 2025 -1320 0 0 {name=l245 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2025 -1340 0 0 {name=l246 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2255 -1400 0 1 {name=l247 sig_type=std_logic lab=vmem_4_3
}
C {devices/lab_pin.sym} 2100 -1290 3 0 {name=l248 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2122.5 -1290 3 0 {name=l249 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2025 -1380 2 1 {name=l250 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 2025 -1400 2 1 {name=l251 sig_type=std_logic lab=vg_3

}
C {/media/sf_share/final_project/cap_mem.sym} 2595 -1360 0 0 {name=x36}
C {devices/lab_pin.sym} 2445 -1320 0 0 {name=l253 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2445 -1340 0 0 {name=l254 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 2675 -1400 0 1 {name=l255 sig_type=std_logic lab=vmem_4_4
}
C {devices/lab_pin.sym} 2520 -1290 3 0 {name=l256 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2542.5 -1290 3 0 {name=l257 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2445 -1380 2 1 {name=l258 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 2445 -1400 2 1 {name=l259 sig_type=std_logic lab=vg_4

}
C {/media/sf_share/final_project/cap_mem.sym} 3015 -1360 0 0 {name=x37}
C {devices/lab_pin.sym} 2865 -1320 0 0 {name=l261 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 2865 -1340 0 0 {name=l262 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3095 -1400 0 1 {name=l263 sig_type=std_logic lab=vmem_4_5
}
C {devices/lab_pin.sym} 2940 -1290 3 0 {name=l264 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 2962.5 -1290 3 0 {name=l265 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 2865 -1400 2 1 {name=l267 sig_type=std_logic lab=vg_5

}
C {/media/sf_share/final_project/cap_mem.sym} 3435 -1360 0 0 {name=x38}
C {devices/lab_pin.sym} 3285 -1320 0 0 {name=l269 sig_type=std_logic lab=vleak}
C {devices/lab_pin.sym} 3285 -1340 0 0 {name=l270 sig_type=std_logic lab=vbias}
C {devices/lab_pin.sym} 3515 -1400 0 1 {name=l271 sig_type=std_logic lab=vmem_4_6
}
C {devices/lab_pin.sym} 3360 -1290 3 0 {name=l272 sig_type=std_logic lab=vbias1}
C {devices/lab_pin.sym} 3382.5 -1290 3 0 {name=l273 sig_type=std_logic lab=vbias2}
C {devices/lab_pin.sym} 3285 -1400 2 1 {name=l275 sig_type=std_logic lab=vg_6

}
C {devices/lab_pin.sym} 2865 -1950 2 1 {name=l146 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 2865 -1760 2 1 {name=l154 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 2865 -1570 2 1 {name=l186 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 2865 -1380 2 1 {name=l194 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 3285 -1950 2 1 {name=l226 sig_type=std_logic lab=vspike_1

}
C {devices/lab_pin.sym} 3285 -1760 2 1 {name=l234 sig_type=std_logic lab=vspike_2

}
C {devices/lab_pin.sym} 3285 -1570 2 1 {name=l266 sig_type=std_logic lab=vspike_3

}
C {devices/lab_pin.sym} 3285 -1380 2 1 {name=l274 sig_type=std_logic lab=vspike_4

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 2417.5 -2855 0 1 {name=M13
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 2507.5 -2945 0 0 {name=M14
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 2397.5 -2825 0 0 {name=l4 lab=GND}
C {devices/vdd.sym} 2527.5 -2975 0 0 {name=l6 lab=VDD}
C {devices/ammeter.sym} 2527.5 -2775 0 0 {name=Vmeas_in1}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 2170 -2855 0 1 {name=M15
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 2260 -2945 0 0 {name=M16
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 2150 -2825 0 0 {name=l22 lab=GND}
C {devices/vdd.sym} 2280 -2975 0 0 {name=l27 lab=VDD}
C {devices/ammeter.sym} 2280 -2775 0 0 {name=Vmeas_in2}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 1917.5 -2855 0 1 {name=M17
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 2007.5 -2945 0 0 {name=M18
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 1897.5 -2825 0 0 {name=l28 lab=GND}
C {devices/vdd.sym} 2027.5 -2975 0 0 {name=l29 lab=VDD}
C {devices/ammeter.sym} 2027.5 -2775 0 0 {name=Vmeas_in3}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 1657.5 -2855 0 1 {name=M19
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 1747.5 -2945 0 0 {name=M20
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 1637.5 -2825 0 0 {name=l30 lab=GND}
C {devices/vdd.sym} 1767.5 -2975 0 0 {name=l31 lab=VDD}
C {devices/ammeter.sym} 1767.5 -2775 0 0 {name=Vmeas_in4}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 1392.5 -2855 0 1 {name=M21
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 1482.5 -2945 0 0 {name=M22
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 1372.5 -2825 0 0 {name=l32 lab=GND}
C {devices/vdd.sym} 1502.5 -2975 0 0 {name=l33 lab=VDD}
C {devices/ammeter.sym} 1502.5 -2775 0 0 {name=Vmeas_in5}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 1135 -2855 0 1 {name=M23
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 1225 -2945 0 0 {name=M24
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 1115 -2825 0 0 {name=l34 lab=GND}
C {devices/vdd.sym} 1245 -2975 0 0 {name=l36 lab=VDD}
C {devices/ammeter.sym} 1245 -2775 0 0 {name=Vmeas_in6}
C {devices/lab_pin.sym} 5785 -3440 0 1 {name=l42 sig_type=std_logic lab=WTAin_1}
C {devices/lab_pin.sym} 3655 -3667.5 2 1 {name=l43 sig_type=std_logic lab=vspike_1

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -3837.5 0 1 {name=M8
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4235 -3667.5 0 0 {name=M9
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4395 -3667.5 0 0 {name=M25
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4595 -3837.5 0 1 {name=M26
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -3557.5 0 1 {name=M27
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4415 -3987.5 0 0 {name=l44 lab=VDD}
C {devices/gnd.sym} 4415 -3527.5 0 0 {name=l45 lab=GND}
C {devices/lab_pin.sym} 4615 -3837.5 1 1 {name=l48 sig_type=std_logic lab=vmem_2_1}
C {devices/lab_pin.sym} 4455 -3557.5 0 1 {name=l54 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4255 -3697.5 0 0 {name=l55 lab=VDD}
C {devices/vdd.sym} 4575 -3867.5 0 0 {name=l276 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4645 -3957.5 0 0 {name=M28
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4435 -3957.5 0 1 {name=M29
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4665 -3987.5 0 0 {name=l277 lab=VDD}
C {devices/lab_pin.sym} 4215 -3667.5 2 1 {name=l278 sig_type=std_logic lab=vspike_2

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -3837.5 0 1 {name=M30
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4795 -3667.5 0 0 {name=M31
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4955 -3667.5 0 0 {name=M32
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5155 -3837.5 0 1 {name=M33
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -3557.5 0 1 {name=M34
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4975 -3987.5 0 0 {name=l279 lab=VDD}
C {devices/gnd.sym} 4975 -3527.5 0 0 {name=l280 lab=GND}
C {devices/lab_pin.sym} 5175 -3837.5 1 1 {name=l281 sig_type=std_logic lab=vmem_3_1}
C {devices/lab_pin.sym} 5015 -3557.5 0 1 {name=l282 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4815 -3697.5 0 0 {name=l283 lab=VDD}
C {devices/vdd.sym} 5135 -3867.5 0 0 {name=l284 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5205 -3957.5 0 0 {name=M35
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4995 -3957.5 0 1 {name=M36
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5225 -3987.5 0 0 {name=l285 lab=VDD}
C {devices/lab_pin.sym} 4775 -3667.5 2 1 {name=l286 sig_type=std_logic lab=vspike_3

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -3837.5 0 1 {name=M37
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5355 -3667.5 0 0 {name=M38
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5515 -3667.5 0 0 {name=M39
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5715 -3837.5 0 1 {name=M40
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -3557.5 0 1 {name=M41
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5535 -3987.5 0 0 {name=l287 lab=VDD}
C {devices/gnd.sym} 5535 -3527.5 0 0 {name=l288 lab=GND}
C {devices/lab_pin.sym} 5735 -3837.5 1 1 {name=l289 sig_type=std_logic lab=vmem_4_1}
C {devices/lab_pin.sym} 5575 -3557.5 0 1 {name=l290 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 5375 -3697.5 0 0 {name=l291 lab=VDD}
C {devices/vdd.sym} 5695 -3867.5 0 0 {name=l292 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5765 -3957.5 0 0 {name=M42
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5555 -3957.5 0 1 {name=M43
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5785 -3987.5 0 0 {name=l293 lab=VDD}
C {devices/lab_pin.sym} 5335 -3667.5 2 1 {name=l294 sig_type=std_logic lab=vspike_4

}
C {devices/lab_pin.sym} 2397.5 -3027.5 0 1 {name=l295 sig_type=std_logic lab=WTAin_1}
C {devices/lab_pin.sym} 2150 -3025 0 1 {name=l296 sig_type=std_logic lab=WTAin_2}
C {devices/lab_pin.sym} 1897.5 -3025 0 1 {name=l297 sig_type=std_logic lab=WTAin_3}
C {devices/lab_pin.sym} 1637.5 -3025 0 1 {name=l298 sig_type=std_logic lab=WTAin_4}
C {devices/lab_pin.sym} 1372.5 -3025 0 1 {name=l299 sig_type=std_logic lab=WTAin_5}
C {devices/lab_pin.sym} 1115 -3025 0 1 {name=l300 sig_type=std_logic lab=WTAin_6}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -3237.5 0 1 {name=M44
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3675 -3067.5 0 0 {name=M45
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3835 -3067.5 0 0 {name=M46
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4035 -3237.5 0 1 {name=M47
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -2957.5 0 1 {name=M48
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 3855 -3387.5 0 0 {name=l301 lab=VDD}
C {devices/gnd.sym} 3855 -2927.5 0 0 {name=l302 lab=GND}
C {devices/lab_pin.sym} 4055 -3237.5 1 1 {name=l303 sig_type=std_logic lab=vmem_1_2}
C {devices/lab_pin.sym} 3895 -2957.5 0 1 {name=l304 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 3695 -3097.5 0 0 {name=l305 lab=VDD}
C {devices/vdd.sym} 4015 -3267.5 0 0 {name=l306 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4085 -3357.5 0 0 {name=M49
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3875 -3357.5 0 1 {name=M50
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4105 -3387.5 0 0 {name=l307 lab=VDD}
C {devices/lab_pin.sym} 5785 -2840 0 1 {name=l308 sig_type=std_logic lab=WTAin_2}
C {devices/lab_pin.sym} 3655 -3067.5 2 1 {name=l309 sig_type=std_logic lab=vspike_1

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -3237.5 0 1 {name=M51
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4235 -3067.5 0 0 {name=M52
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4395 -3067.5 0 0 {name=M53
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4595 -3237.5 0 1 {name=M54
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -2957.5 0 1 {name=M55
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4415 -3387.5 0 0 {name=l310 lab=VDD}
C {devices/gnd.sym} 4415 -2927.5 0 0 {name=l311 lab=GND}
C {devices/lab_pin.sym} 4615 -3237.5 1 1 {name=l312 sig_type=std_logic lab=vmem_2_2}
C {devices/lab_pin.sym} 4455 -2957.5 0 1 {name=l313 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4255 -3097.5 0 0 {name=l314 lab=VDD}
C {devices/vdd.sym} 4575 -3267.5 0 0 {name=l315 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4645 -3357.5 0 0 {name=M56
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4435 -3357.5 0 1 {name=M57
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4665 -3387.5 0 0 {name=l316 lab=VDD}
C {devices/lab_pin.sym} 4215 -3067.5 2 1 {name=l317 sig_type=std_logic lab=vspike_2

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -3237.5 0 1 {name=M58
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4795 -3067.5 0 0 {name=M59
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4955 -3067.5 0 0 {name=M60
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5155 -3237.5 0 1 {name=M61
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -2957.5 0 1 {name=M62
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4975 -3387.5 0 0 {name=l318 lab=VDD}
C {devices/gnd.sym} 4975 -2927.5 0 0 {name=l319 lab=GND}
C {devices/lab_pin.sym} 5175 -3237.5 1 1 {name=l320 sig_type=std_logic lab=vmem_3_2}
C {devices/lab_pin.sym} 5015 -2957.5 0 1 {name=l321 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4815 -3097.5 0 0 {name=l322 lab=VDD}
C {devices/vdd.sym} 5135 -3267.5 0 0 {name=l323 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5205 -3357.5 0 0 {name=M63
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4995 -3357.5 0 1 {name=M64
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5225 -3387.5 0 0 {name=l324 lab=VDD}
C {devices/lab_pin.sym} 4775 -3067.5 2 1 {name=l325 sig_type=std_logic lab=vspike_3

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -3237.5 0 1 {name=M65
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5355 -3067.5 0 0 {name=M66
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5515 -3067.5 0 0 {name=M67
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5715 -3237.5 0 1 {name=M68
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -2957.5 0 1 {name=M69
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5535 -3387.5 0 0 {name=l326 lab=VDD}
C {devices/gnd.sym} 5535 -2927.5 0 0 {name=l327 lab=GND}
C {devices/lab_pin.sym} 5735 -3237.5 1 1 {name=l328 sig_type=std_logic lab=vmem_4_2}
C {devices/lab_pin.sym} 5575 -2957.5 0 1 {name=l329 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 5375 -3097.5 0 0 {name=l330 lab=VDD}
C {devices/vdd.sym} 5695 -3267.5 0 0 {name=l331 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5765 -3357.5 0 0 {name=M70
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5555 -3357.5 0 1 {name=M71
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5785 -3387.5 0 0 {name=l332 lab=VDD}
C {devices/lab_pin.sym} 5335 -3067.5 2 1 {name=l333 sig_type=std_logic lab=vspike_4

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -2637.5 0 1 {name=M72
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3675 -2467.5 0 0 {name=M73
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3835 -2467.5 0 0 {name=M74
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4035 -2637.5 0 1 {name=M75
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -2357.5 0 1 {name=M76
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 3855 -2787.5 0 0 {name=l334 lab=VDD}
C {devices/gnd.sym} 3855 -2327.5 0 0 {name=l335 lab=GND}
C {devices/lab_pin.sym} 4055 -2637.5 1 1 {name=l336 sig_type=std_logic lab=vmem_1_3}
C {devices/lab_pin.sym} 3895 -2357.5 0 1 {name=l337 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 3695 -2497.5 0 0 {name=l338 lab=VDD}
C {devices/vdd.sym} 4015 -2667.5 0 0 {name=l339 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4085 -2757.5 0 0 {name=M77
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3875 -2757.5 0 1 {name=M78
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4105 -2787.5 0 0 {name=l340 lab=VDD}
C {devices/lab_pin.sym} 5785 -2240 0 1 {name=l341 sig_type=std_logic lab=WTAin_3}
C {devices/lab_pin.sym} 3655 -2467.5 2 1 {name=l342 sig_type=std_logic lab=vspike_1

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -2637.5 0 1 {name=M79
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4235 -2467.5 0 0 {name=M80
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4395 -2467.5 0 0 {name=M81
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4595 -2637.5 0 1 {name=M82
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -2357.5 0 1 {name=M83
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4415 -2787.5 0 0 {name=l343 lab=VDD}
C {devices/gnd.sym} 4415 -2327.5 0 0 {name=l344 lab=GND}
C {devices/lab_pin.sym} 4615 -2637.5 1 1 {name=l345 sig_type=std_logic lab=vmem_2_3}
C {devices/lab_pin.sym} 4455 -2357.5 0 1 {name=l346 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4255 -2497.5 0 0 {name=l347 lab=VDD}
C {devices/vdd.sym} 4575 -2667.5 0 0 {name=l348 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4645 -2757.5 0 0 {name=M84
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4435 -2757.5 0 1 {name=M85
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4665 -2787.5 0 0 {name=l349 lab=VDD}
C {devices/lab_pin.sym} 4215 -2467.5 2 1 {name=l350 sig_type=std_logic lab=vspike_2

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -2637.5 0 1 {name=M86
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4795 -2467.5 0 0 {name=M87
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4955 -2467.5 0 0 {name=M88
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5155 -2637.5 0 1 {name=M89
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -2357.5 0 1 {name=M90
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4975 -2787.5 0 0 {name=l351 lab=VDD}
C {devices/gnd.sym} 4975 -2327.5 0 0 {name=l352 lab=GND}
C {devices/lab_pin.sym} 5175 -2637.5 1 1 {name=l353 sig_type=std_logic lab=vmem_3_3}
C {devices/lab_pin.sym} 5015 -2357.5 0 1 {name=l354 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4815 -2497.5 0 0 {name=l355 lab=VDD}
C {devices/vdd.sym} 5135 -2667.5 0 0 {name=l356 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5205 -2757.5 0 0 {name=M91
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4995 -2757.5 0 1 {name=M92
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5225 -2787.5 0 0 {name=l357 lab=VDD}
C {devices/lab_pin.sym} 4775 -2467.5 2 1 {name=l358 sig_type=std_logic lab=vspike_3

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -2637.5 0 1 {name=M93
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5355 -2467.5 0 0 {name=M94
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5515 -2467.5 0 0 {name=M95
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5715 -2637.5 0 1 {name=M96
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -2357.5 0 1 {name=M97
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5535 -2787.5 0 0 {name=l359 lab=VDD}
C {devices/gnd.sym} 5535 -2327.5 0 0 {name=l360 lab=GND}
C {devices/lab_pin.sym} 5735 -2637.5 1 1 {name=l361 sig_type=std_logic lab=vmem_4_3}
C {devices/lab_pin.sym} 5575 -2357.5 0 1 {name=l362 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 5375 -2497.5 0 0 {name=l363 lab=VDD}
C {devices/vdd.sym} 5695 -2667.5 0 0 {name=l364 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5765 -2757.5 0 0 {name=M98
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5555 -2757.5 0 1 {name=M99
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5785 -2787.5 0 0 {name=l365 lab=VDD}
C {devices/lab_pin.sym} 5335 -2467.5 2 1 {name=l366 sig_type=std_logic lab=vspike_4

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -2037.5 0 1 {name=M100
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3675 -1867.5 0 0 {name=M101
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3835 -1867.5 0 0 {name=M102
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4035 -2037.5 0 1 {name=M103
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -1757.5 0 1 {name=M104
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 3855 -2187.5 0 0 {name=l367 lab=VDD}
C {devices/gnd.sym} 3855 -1727.5 0 0 {name=l368 lab=GND}
C {devices/lab_pin.sym} 4055 -2037.5 1 1 {name=l369 sig_type=std_logic lab=vmem_1_4}
C {devices/lab_pin.sym} 3895 -1757.5 0 1 {name=l370 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 3695 -1897.5 0 0 {name=l371 lab=VDD}
C {devices/vdd.sym} 4015 -2067.5 0 0 {name=l372 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4085 -2157.5 0 0 {name=M105
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3875 -2157.5 0 1 {name=M106
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4105 -2187.5 0 0 {name=l373 lab=VDD}
C {devices/lab_pin.sym} 5785 -1640 0 1 {name=l374 sig_type=std_logic lab=WTAin_4}
C {devices/lab_pin.sym} 3655 -1867.5 2 1 {name=l375 sig_type=std_logic lab=vspike_1

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -2037.5 0 1 {name=M107
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4235 -1867.5 0 0 {name=M108
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4395 -1867.5 0 0 {name=M109
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4595 -2037.5 0 1 {name=M110
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -1757.5 0 1 {name=M111
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4415 -2187.5 0 0 {name=l376 lab=VDD}
C {devices/gnd.sym} 4415 -1727.5 0 0 {name=l377 lab=GND}
C {devices/lab_pin.sym} 4615 -2037.5 1 1 {name=l378 sig_type=std_logic lab=vmem_2_4}
C {devices/lab_pin.sym} 4455 -1757.5 0 1 {name=l379 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4255 -1897.5 0 0 {name=l380 lab=VDD}
C {devices/vdd.sym} 4575 -2067.5 0 0 {name=l381 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4645 -2157.5 0 0 {name=M112
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4435 -2157.5 0 1 {name=M113
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4665 -2187.5 0 0 {name=l382 lab=VDD}
C {devices/lab_pin.sym} 4215 -1867.5 2 1 {name=l383 sig_type=std_logic lab=vspike_2

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -2037.5 0 1 {name=M114
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4795 -1867.5 0 0 {name=M115
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4955 -1867.5 0 0 {name=M116
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5155 -2037.5 0 1 {name=M117
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -1757.5 0 1 {name=M118
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4975 -2187.5 0 0 {name=l384 lab=VDD}
C {devices/gnd.sym} 4975 -1727.5 0 0 {name=l385 lab=GND}
C {devices/lab_pin.sym} 5175 -2037.5 1 1 {name=l386 sig_type=std_logic lab=vmem_3_4}
C {devices/lab_pin.sym} 5015 -1757.5 0 1 {name=l387 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4815 -1897.5 0 0 {name=l388 lab=VDD}
C {devices/vdd.sym} 5135 -2067.5 0 0 {name=l389 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5205 -2157.5 0 0 {name=M119
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4995 -2157.5 0 1 {name=M120
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5225 -2187.5 0 0 {name=l390 lab=VDD}
C {devices/lab_pin.sym} 4775 -1867.5 2 1 {name=l391 sig_type=std_logic lab=vspike_3

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -2037.5 0 1 {name=M121
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5355 -1867.5 0 0 {name=M122
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5515 -1867.5 0 0 {name=M123
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5715 -2037.5 0 1 {name=M124
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -1757.5 0 1 {name=M125
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5535 -2187.5 0 0 {name=l392 lab=VDD}
C {devices/gnd.sym} 5535 -1727.5 0 0 {name=l393 lab=GND}
C {devices/lab_pin.sym} 5735 -2037.5 1 1 {name=l394 sig_type=std_logic lab=vmem_4_4}
C {devices/lab_pin.sym} 5575 -1757.5 0 1 {name=l395 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 5375 -1897.5 0 0 {name=l396 lab=VDD}
C {devices/vdd.sym} 5695 -2067.5 0 0 {name=l397 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5765 -2157.5 0 0 {name=M126
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5555 -2157.5 0 1 {name=M127
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5785 -2187.5 0 0 {name=l398 lab=VDD}
C {devices/lab_pin.sym} 5335 -1867.5 2 1 {name=l399 sig_type=std_logic lab=vspike_4

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -1427.5 0 1 {name=M128
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3675 -1257.5 0 0 {name=M129
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3835 -1257.5 0 0 {name=M130
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4035 -1427.5 0 1 {name=M131
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -1147.5 0 1 {name=M132
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 3855 -1577.5 0 0 {name=l400 lab=VDD}
C {devices/gnd.sym} 3855 -1117.5 0 0 {name=l401 lab=GND}
C {devices/lab_pin.sym} 4055 -1427.5 1 1 {name=l402 sig_type=std_logic lab=vmem_1_5}
C {devices/lab_pin.sym} 3895 -1147.5 0 1 {name=l403 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 3695 -1287.5 0 0 {name=l404 lab=VDD}
C {devices/vdd.sym} 4015 -1457.5 0 0 {name=l405 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4085 -1547.5 0 0 {name=M133
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3875 -1547.5 0 1 {name=M134
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4105 -1577.5 0 0 {name=l406 lab=VDD}
C {devices/lab_pin.sym} 5785 -1030 0 1 {name=l407 sig_type=std_logic lab=WTAin_5}
C {devices/lab_pin.sym} 3655 -1257.5 2 1 {name=l408 sig_type=std_logic lab=vspike_1

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -1427.5 0 1 {name=M135
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4235 -1257.5 0 0 {name=M136
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4395 -1257.5 0 0 {name=M137
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4595 -1427.5 0 1 {name=M138
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -1147.5 0 1 {name=M139
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4415 -1577.5 0 0 {name=l409 lab=VDD}
C {devices/gnd.sym} 4415 -1117.5 0 0 {name=l410 lab=GND}
C {devices/lab_pin.sym} 4615 -1427.5 1 1 {name=l411 sig_type=std_logic lab=vmem_2_5}
C {devices/lab_pin.sym} 4455 -1147.5 0 1 {name=l412 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4255 -1287.5 0 0 {name=l413 lab=VDD}
C {devices/vdd.sym} 4575 -1457.5 0 0 {name=l414 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4645 -1547.5 0 0 {name=M140
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4435 -1547.5 0 1 {name=M141
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4665 -1577.5 0 0 {name=l415 lab=VDD}
C {devices/lab_pin.sym} 4215 -1257.5 2 1 {name=l416 sig_type=std_logic lab=vspike_2

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -1427.5 0 1 {name=M142
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4795 -1257.5 0 0 {name=M143
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4955 -1257.5 0 0 {name=M144
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5155 -1427.5 0 1 {name=M145
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -1147.5 0 1 {name=M146
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4975 -1577.5 0 0 {name=l417 lab=VDD}
C {devices/gnd.sym} 4975 -1117.5 0 0 {name=l418 lab=GND}
C {devices/lab_pin.sym} 5175 -1427.5 1 1 {name=l419 sig_type=std_logic lab=vmem_3_5}
C {devices/lab_pin.sym} 5015 -1147.5 0 1 {name=l420 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4815 -1287.5 0 0 {name=l421 lab=VDD}
C {devices/vdd.sym} 5135 -1457.5 0 0 {name=l422 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5205 -1547.5 0 0 {name=M147
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4995 -1547.5 0 1 {name=M148
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5225 -1577.5 0 0 {name=l423 lab=VDD}
C {devices/lab_pin.sym} 4775 -1257.5 2 1 {name=l424 sig_type=std_logic lab=vspike_3

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -1427.5 0 1 {name=M149
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5355 -1257.5 0 0 {name=M150
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5515 -1257.5 0 0 {name=M151
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5715 -1427.5 0 1 {name=M152
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -1147.5 0 1 {name=M153
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5535 -1577.5 0 0 {name=l425 lab=VDD}
C {devices/gnd.sym} 5535 -1117.5 0 0 {name=l426 lab=GND}
C {devices/lab_pin.sym} 5735 -1427.5 1 1 {name=l427 sig_type=std_logic lab=vmem_4_5}
C {devices/lab_pin.sym} 5575 -1147.5 0 1 {name=l428 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 5375 -1287.5 0 0 {name=l429 lab=VDD}
C {devices/vdd.sym} 5695 -1457.5 0 0 {name=l430 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5765 -1547.5 0 0 {name=M154
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5555 -1547.5 0 1 {name=M155
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5785 -1577.5 0 0 {name=l431 lab=VDD}
C {devices/lab_pin.sym} 5335 -1257.5 2 1 {name=l432 sig_type=std_logic lab=vspike_4

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -827.5 0 1 {name=M156
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3675 -657.5 0 0 {name=M157
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3835 -657.5 0 0 {name=M158
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4035 -827.5 0 1 {name=M159
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 3875 -547.5 0 1 {name=M160
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 3855 -977.5 0 0 {name=l433 lab=VDD}
C {devices/gnd.sym} 3855 -517.5 0 0 {name=l434 lab=GND}
C {devices/lab_pin.sym} 4055 -827.5 1 1 {name=l435 sig_type=std_logic lab=vmem_1_6}
C {devices/lab_pin.sym} 3895 -547.5 0 1 {name=l436 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 3695 -687.5 0 0 {name=l437 lab=VDD}
C {devices/vdd.sym} 4015 -857.5 0 0 {name=l438 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4085 -947.5 0 0 {name=M161
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 3875 -947.5 0 1 {name=M162
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4105 -977.5 0 0 {name=l439 lab=VDD}
C {devices/lab_pin.sym} 5785 -430 0 1 {name=l440 sig_type=std_logic lab=WTAin_6}
C {devices/lab_pin.sym} 3655 -657.5 2 1 {name=l441 sig_type=std_logic lab=vspike_1

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -827.5 0 1 {name=M163
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4235 -657.5 0 0 {name=M164
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4395 -657.5 0 0 {name=M165
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4595 -827.5 0 1 {name=M166
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4435 -547.5 0 1 {name=M167
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4415 -977.5 0 0 {name=l442 lab=VDD}
C {devices/gnd.sym} 4415 -517.5 0 0 {name=l443 lab=GND}
C {devices/lab_pin.sym} 4615 -827.5 1 1 {name=l444 sig_type=std_logic lab=vmem_2_6}
C {devices/lab_pin.sym} 4455 -547.5 0 1 {name=l445 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4255 -687.5 0 0 {name=l446 lab=VDD}
C {devices/vdd.sym} 4575 -857.5 0 0 {name=l447 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4645 -947.5 0 0 {name=M168
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4435 -947.5 0 1 {name=M169
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4665 -977.5 0 0 {name=l448 lab=VDD}
C {devices/lab_pin.sym} 4215 -657.5 2 1 {name=l449 sig_type=std_logic lab=vspike_2

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -827.5 0 1 {name=M170
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4795 -657.5 0 0 {name=M171
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4955 -657.5 0 0 {name=M172
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5155 -827.5 0 1 {name=M173
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 4995 -547.5 0 1 {name=M174
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 4975 -977.5 0 0 {name=l450 lab=VDD}
C {devices/gnd.sym} 4975 -517.5 0 0 {name=l451 lab=GND}
C {devices/lab_pin.sym} 5175 -827.5 1 1 {name=l452 sig_type=std_logic lab=vmem_3_6}
C {devices/lab_pin.sym} 5015 -547.5 0 1 {name=l453 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 4815 -687.5 0 0 {name=l454 lab=VDD}
C {devices/vdd.sym} 5135 -857.5 0 0 {name=l455 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5205 -947.5 0 0 {name=M175
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 4995 -947.5 0 1 {name=M176
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5225 -977.5 0 0 {name=l456 lab=VDD}
C {devices/lab_pin.sym} 4775 -657.5 2 1 {name=l457 sig_type=std_logic lab=vspike_3

}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -827.5 0 1 {name=M177
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5355 -657.5 0 0 {name=M178
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5515 -657.5 0 0 {name=M179
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5715 -827.5 0 1 {name=M180
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet3_g5v0d10v5.sym} 5555 -547.5 0 1 {name=M181
L=1
W=1
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5535 -977.5 0 0 {name=l458 lab=VDD}
C {devices/gnd.sym} 5535 -517.5 0 0 {name=l459 lab=GND}
C {devices/lab_pin.sym} 5735 -827.5 1 1 {name=l460 sig_type=std_logic lab=vmem_4_6}
C {devices/lab_pin.sym} 5575 -547.5 0 1 {name=l461 sig_type=std_logic lab=vbias_bump}
C {devices/vdd.sym} 5375 -687.5 0 0 {name=l462 lab=VDD}
C {devices/vdd.sym} 5695 -857.5 0 0 {name=l463 lab=VDD}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5765 -947.5 0 0 {name=M182
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet3_g5v0d10v5.sym} 5555 -947.5 0 1 {name=M183
L=1
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 5785 -977.5 0 0 {name=l464 lab=VDD}
C {devices/lab_pin.sym} 5335 -657.5 2 1 {name=l465 sig_type=std_logic lab=vspike_4

}
C {/media/sf_share/final_project/buffer.sym} 2437.5 -3020 0 0 {name=x4}
C {devices/lab_pin.sym} 2557.5 -3100 0 1 {name=l466 sig_type=std_logic lab=neuron_1}
C {/media/sf_share/final_project/buffer.sym} 2190 -3020 0 0 {name=x5}
C {devices/lab_pin.sym} 2310 -3100 0 1 {name=l467 sig_type=std_logic lab=neuron_2}
C {/media/sf_share/final_project/buffer.sym} 1937.5 -3020 0 0 {name=x39}
C {devices/lab_pin.sym} 2057.5 -3100 0 1 {name=l468 sig_type=std_logic lab=neuron_3}
C {/media/sf_share/final_project/buffer.sym} 1677.5 -3020 0 0 {name=x40}
C {devices/lab_pin.sym} 1797.5 -3100 0 1 {name=l469 sig_type=std_logic lab=neuron_4}
C {/media/sf_share/final_project/buffer.sym} 1412.5 -3020 0 0 {name=x41}
C {devices/lab_pin.sym} 1532.5 -3100 0 1 {name=l470 sig_type=std_logic lab=neuron_5}
C {/media/sf_share/final_project/buffer.sym} 1155 -3020 0 0 {name=x42}
C {devices/lab_pin.sym} 1275 -3100 0 1 {name=l471 sig_type=std_logic lab=neuron_6}
C {devices/isource.sym} 2972.5 -2975 0 0 {name=I0 value=5uA}
C {devices/ammeter.sym} 4105 -3552.5 0 0 {name=Vmeas}
C {devices/ammeter.sym} 4665 -3552.5 0 0 {name=Vmeas1}
C {devices/ammeter.sym} 5225 -3552.5 0 0 {name=Vmeas2}
C {devices/ammeter.sym} 5785 -3552.5 0 0 {name=Vmeas3}
