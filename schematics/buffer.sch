v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 330 -1470 0 0 {name=p1 lab=a}
C {devices/opin.sym} 350 -1470 0 0 {name=p2 lab=b}
C {/media/sf_share/final_project/inverter.sym} 350 -1280 0 0 {name=x1}
C {/media/sf_share/final_project/inverter.sym} 530 -1280 0 0 {name=x2}
C {devices/lab_pin.sym} 310 -1360 0 0 {name=l1 sig_type=std_logic lab=a}
C {devices/lab_pin.sym} 670 -1360 0 1 {name=l2 sig_type=std_logic lab=b}
